v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {ctrl_counters: controller flow box "Counters K and N" at transistor level (69 cells)} 0 -230 0 0 0.45 0.45 {}
T {Synthesized from meta_controller.v; every cell opened up. Stage labels are the cell instance names.} 0 -190 0 0 0.26 0.26 {}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36380 1370 0 0 {name=M126_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36380 60 0 0 {name=M126_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 140 1370 0 0 {name=M156_i_2 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 340 1370 0 0 {name=M156_i_3 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6460 1370 0 0 {name=M156_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 140 210 0 0 {name=M156_i_4 L=0.5u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 140 60 0 0 {name=M156_i_5 L=0.5u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6460 60 0 0 {name=M156_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13540 1370 0 0 {name=M171_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13540 1220 0 0 {name=M171_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13740 1370 0 0 {name=M171_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13540 210 0 0 {name=M171_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13740 210 0 0 {name=M171_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13540 60 0 0 {name=M171_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14100 1070 0 0 {name=M172_i_2 L=0.6u W=0.38u nf=1 m=1 ad=1.9e-13 as=1.9e-13 pd=1.76e-06 ps=1.76e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14100 1220 0 0 {name=M172_i_3 L=0.6u W=0.38u nf=1 m=1 ad=1.9e-13 as=1.9e-13 pd=1.76e-06 ps=1.76e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14100 1370 0 0 {name=M172_i_4 L=0.6u W=0.38u nf=1 m=1 ad=1.9e-13 as=1.9e-13 pd=1.76e-06 ps=1.76e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14860 1370 0 0 {name=M172_i_0 L=0.6u W=0.775u nf=1 m=1 ad=3.875e-13 as=3.875e-13 pd=2.55e-06 ps=2.55e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14100 60 0 0 {name=M172_i_5 L=0.5u W=0.535u nf=1 m=1 ad=2.675e-13 as=2.675e-13 pd=2.07e-06 ps=2.07e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14300 60 0 0 {name=M172_i_6 L=0.5u W=0.535u nf=1 m=1 ad=2.675e-13 as=2.675e-13 pd=2.07e-06 ps=2.07e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14500 60 0 0 {name=M172_i_7 L=0.5u W=0.535u nf=1 m=1 ad=2.675e-13 as=2.675e-13 pd=2.07e-06 ps=2.07e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14860 60 0 0 {name=M172_i_1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15220 1370 0 0 {name=M173_i_2 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15420 1370 0 0 {name=M173_i_1 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15620 1370 0 0 {name=M173_i_0 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15220 60 0 0 {name=M173_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15220 210 0 0 {name=M173_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15220 360 0 0 {name=M173_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27940 1370 0 0 {name=M174_i_3 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27940 1220 0 0 {name=M174_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27940 1070 0 0 {name=M174_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27940 920 0 0 {name=M174_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27940 60 0 0 {name=M174_i_7 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28140 60 0 0 {name=M174_i_6 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28340 60 0 0 {name=M174_i_5 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28540 60 0 0 {name=M174_i_4 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31140 1220 0 0 {name=M175_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31340 1220 0 0 {name=M175_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31140 1370 0 0 {name=M175_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31140 60 0 0 {name=M175_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31140 210 0 0 {name=M175_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31340 60 0 0 {name=M175_i_5 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18060 1370 0 0 {name=M176_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18260 1370 0 0 {name=M176_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18060 60 0 0 {name=M176_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18060 210 0 0 {name=M176_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31700 920 0 0 {name=M177_i_2 L=0.6u W=0.42u nf=1 m=1 ad=2.1e-13 as=2.1e-13 pd=1.84e-06 ps=1.84e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31700 1070 0 0 {name=M177_i_3 L=0.6u W=0.42u nf=1 m=1 ad=2.1e-13 as=2.1e-13 pd=1.84e-06 ps=1.84e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31700 1220 0 0 {name=M177_i_4 L=0.6u W=0.42u nf=1 m=1 ad=2.1e-13 as=2.1e-13 pd=1.84e-06 ps=1.84e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31700 1370 0 0 {name=M177_i_5 L=0.6u W=0.42u nf=1 m=1 ad=2.1e-13 as=2.1e-13 pd=1.84e-06 ps=1.84e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32660 1370 0 0 {name=M177_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31700 60 0 0 {name=M177_i_6 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31900 60 0 0 {name=M177_i_7 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32100 60 0 0 {name=M177_i_8 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32300 60 0 0 {name=M177_i_9 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32660 60 0 0 {name=M177_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33020 1370 0 0 {name=M178_i_3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33020 1220 0 0 {name=M178_i_2 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33220 1220 0 0 {name=M178_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33220 1370 0 0 {name=M178_i_1 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33020 60 0 0 {name=M178_i_7 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33220 60 0 0 {name=M178_i_6 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33220 210 0 0 {name=M178_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33020 210 0 0 {name=M178_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18620 1220 0 0 {name=M179_i_2 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18620 1370 0 0 {name=M179_i_3 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19180 1370 0 0 {name=M179_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18620 60 0 0 {name=M179_i_4 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18820 60 0 0 {name=M179_i_5 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19180 60 0 0 {name=M179_i_1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33580 1370 0 0 {name=M180_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33580 1220 0 0 {name=M180_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33780 1370 0 0 {name=M180_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33580 210 0 0 {name=M180_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33780 210 0 0 {name=M180_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33580 60 0 0 {name=M180_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38980 1370 0 0 {name=M181_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38980 1220 0 0 {name=M181_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38980 60 0 0 {name=M181_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39180 60 0 0 {name=M181_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12580 1370 0 0 {name=M182_i_3 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12780 1370 0 0 {name=M182_i_2 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12980 1370 0 0 {name=M182_i_1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13180 1370 0 0 {name=M182_i_0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12580 60 0 0 {name=M182_i_7 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12580 210 0 0 {name=M182_i_6 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12580 360 0 0 {name=M182_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12580 510 0 0 {name=M182_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19540 1370 0 0 {name=M183_i_2 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19740 1370 0 0 {name=M183_i_1 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19940 1370 0 0 {name=M183_i_0 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19540 60 0 0 {name=M183_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19540 210 0 0 {name=M183_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19540 360 0 0 {name=M183_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20300 1220 0 0 {name=M184_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20500 1220 0 0 {name=M184_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20300 1370 0 0 {name=M184_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20300 60 0 0 {name=M184_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20300 210 0 0 {name=M184_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20500 60 0 0 {name=M184_i_5 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40460 1370 0 0 {name=M185_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40460 1220 0 0 {name=M185_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40660 1370 0 0 {name=M185_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40460 210 0 0 {name=M185_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40660 210 0 0 {name=M185_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40460 60 0 0 {name=M185_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43260 1370 0 0 {name=M186_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43260 1220 0 0 {name=M186_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43260 1070 0 0 {name=M186_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43260 60 0 0 {name=M186_i_5 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43460 60 0 0 {name=M186_i_4 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43660 60 0 0 {name=M186_i_3 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44020 1370 0 0 {name=M187_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44020 1220 0 0 {name=M187_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44220 1370 0 0 {name=M187_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44020 210 0 0 {name=M187_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44220 210 0 0 {name=M187_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44020 60 0 0 {name=M187_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20860 1370 0 0 {name=M188_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21060 1370 0 0 {name=M188_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20860 60 0 0 {name=M188_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20860 210 0 0 {name=M188_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44580 1220 0 0 {name=M189_i_2 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44580 1370 0 0 {name=M189_i_3 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45140 1370 0 0 {name=M189_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44580 60 0 0 {name=M189_i_4 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44780 60 0 0 {name=M189_i_5 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45140 60 0 0 {name=M189_i_1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49060 1370 0 0 {name=M190_i_3 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49060 1220 0 0 {name=M190_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49060 1070 0 0 {name=M190_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49060 920 0 0 {name=M190_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49060 60 0 0 {name=M190_i_7 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49260 60 0 0 {name=M190_i_6 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49460 60 0 0 {name=M190_i_5 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49660 60 0 0 {name=M190_i_4 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50020 1370 0 0 {name=M191_i_6 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50220 1370 0 0 {name=M191_i_7 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50580 1370 0 0 {name=M191_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50580 1220 0 0 {name=M191_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50780 1370 0 0 {name=M191_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50020 210 0 0 {name=M191_i_8 L=0.5u W=0.56u nf=1 m=1 ad=2.8e-13 as=2.8e-13 pd=2.12e-06 ps=2.12e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50020 60 0 0 {name=M191_i_9 L=0.5u W=0.56u nf=1 m=1 ad=2.8e-13 as=2.8e-13 pd=2.12e-06 ps=2.12e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50580 60 0 0 {name=M191_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50580 210 0 0 {name=M191_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50780 210 0 0 {name=M191_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21420 1370 0 0 {name=M192_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21620 1370 0 0 {name=M192_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21420 60 0 0 {name=M192_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21420 210 0 0 {name=M192_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53380 1370 0 0 {name=M193_i_6 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53580 1370 0 0 {name=M193_i_7 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53940 1370 0 0 {name=M193_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53940 1220 0 0 {name=M193_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54140 1370 0 0 {name=M193_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53380 210 0 0 {name=M193_i_8 L=0.5u W=0.56u nf=1 m=1 ad=2.8e-13 as=2.8e-13 pd=2.12e-06 ps=2.12e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53380 60 0 0 {name=M193_i_9 L=0.5u W=0.56u nf=1 m=1 ad=2.8e-13 as=2.8e-13 pd=2.12e-06 ps=2.12e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53940 60 0 0 {name=M193_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53940 210 0 0 {name=M193_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54140 210 0 0 {name=M193_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21980 1370 0 0 {name=M194_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22180 1370 0 0 {name=M194_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21980 60 0 0 {name=M194_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21980 210 0 0 {name=M194_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22540 1370 0 0 {name=M195_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22540 1220 0 0 {name=M195_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22540 60 0 0 {name=M195_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22740 60 0 0 {name=M195_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56340 1370 0 0 {name=M196_MN2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55780 1370 0 0 {name=M196_MN4 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55780 1220 0 0 {name=M196_MN8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55980 1220 0 0 {name=M196_MN7 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55980 1370 0 0 {name=M196_MN3 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55420 1370 0 0 {name=M196_MN1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56340 60 0 0 {name=M196_MP5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55780 60 0 0 {name=M196_MP4 L=0.5u W=0.615u nf=1 m=1 ad=3.075e-13 as=3.075e-13 pd=2.23e-06 ps=2.23e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55780 210 0 0 {name=M196_MP8 L=0.5u W=0.615u nf=1 m=1 ad=3.075e-13 as=3.075e-13 pd=2.23e-06 ps=2.23e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55980 210 0 0 {name=M196_MP7 L=0.5u W=0.615u nf=1 m=1 ad=3.075e-13 as=3.075e-13 pd=2.23e-06 ps=2.23e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55980 60 0 0 {name=M196_MP3 L=0.5u W=0.615u nf=1 m=1 ad=3.075e-13 as=3.075e-13 pd=2.23e-06 ps=2.23e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55420 60 0 0 {name=M196_MP1 L=0.5u W=0.615u nf=1 m=1 ad=3.075e-13 as=3.075e-13 pd=2.23e-06 ps=2.23e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60260 1220 0 0 {name=M197_i_6 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60260 1370 0 0 {name=M197_i_7 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60820 1370 0 0 {name=M197_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60820 1220 0 0 {name=M197_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61020 1220 0 0 {name=M197_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60260 60 0 0 {name=M197_i_8 L=0.5u W=0.56u nf=1 m=1 ad=2.8e-13 as=2.8e-13 pd=2.12e-06 ps=2.12e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60460 60 0 0 {name=M197_i_9 L=0.5u W=0.56u nf=1 m=1 ad=2.8e-13 as=2.8e-13 pd=2.12e-06 ps=2.12e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60820 60 0 0 {name=M197_i_5 L=0.5u W=1.095u nf=1 m=1 ad=5.475e-13 as=5.475e-13 pd=3.19e-06 ps=3.19e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60820 210 0 0 {name=M197_i_3 L=0.5u W=1.095u nf=1 m=1 ad=5.475e-13 as=5.475e-13 pd=3.19e-06 ps=3.19e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61020 60 0 0 {name=M197_i_4 L=0.5u W=1.095u nf=1 m=1 ad=5.475e-13 as=5.475e-13 pd=3.19e-06 ps=3.19e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23100 1220 0 0 {name=M198_i_2 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23100 1370 0 0 {name=M198_i_3 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23660 1370 0 0 {name=M198_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23100 60 0 0 {name=M198_i_4 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23300 60 0 0 {name=M198_i_5 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23660 60 0 0 {name=M198_i_1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62300 1370 0 0 {name=M199_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62300 1220 0 0 {name=M199_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62500 1370 0 0 {name=M199_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62300 210 0 0 {name=M199_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62500 210 0 0 {name=M199_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62300 60 0 0 {name=M199_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62860 1370 0 0 {name=M200_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62860 1220 0 0 {name=M200_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62860 1070 0 0 {name=M200_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62860 60 0 0 {name=M200_i_5 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63060 60 0 0 {name=M200_i_4 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63260 60 0 0 {name=M200_i_3 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63620 1370 0 0 {name=M201_i_3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63620 1220 0 0 {name=M201_i_2 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63820 1220 0 0 {name=M201_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63820 1370 0 0 {name=M201_i_1 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63620 60 0 0 {name=M201_i_7 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63820 60 0 0 {name=M201_i_6 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63820 210 0 0 {name=M201_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63620 210 0 0 {name=M201_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64180 1370 0 0 {name=M202_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64380 1370 0 0 {name=M202_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 64180 60 0 0 {name=M202_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 64180 210 0 0 {name=M202_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15980 1370 0 0 {name=M203_i_2 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16180 1370 0 0 {name=M203_i_1 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16380 1370 0 0 {name=M203_i_0 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15980 60 0 0 {name=M203_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15980 210 0 0 {name=M203_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15980 360 0 0 {name=M203_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24020 1220 0 0 {name=M204_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24220 1220 0 0 {name=M204_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24020 1370 0 0 {name=M204_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24020 60 0 0 {name=M204_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24020 210 0 0 {name=M204_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24220 60 0 0 {name=M204_i_5 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 66980 1370 0 0 {name=M205_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 66980 1220 0 0 {name=M205_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 67180 1370 0 0 {name=M205_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 66980 210 0 0 {name=M205_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 67180 210 0 0 {name=M205_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 66980 60 0 0 {name=M205_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 67540 920 0 0 {name=M206_i_2 L=0.6u W=0.42u nf=1 m=1 ad=2.1e-13 as=2.1e-13 pd=1.84e-06 ps=1.84e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 67540 1070 0 0 {name=M206_i_3 L=0.6u W=0.42u nf=1 m=1 ad=2.1e-13 as=2.1e-13 pd=1.84e-06 ps=1.84e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 67540 1220 0 0 {name=M206_i_4 L=0.6u W=0.42u nf=1 m=1 ad=2.1e-13 as=2.1e-13 pd=1.84e-06 ps=1.84e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 67540 1370 0 0 {name=M206_i_5 L=0.6u W=0.42u nf=1 m=1 ad=2.1e-13 as=2.1e-13 pd=1.84e-06 ps=1.84e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 68500 1370 0 0 {name=M206_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 67540 60 0 0 {name=M206_i_6 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 67740 60 0 0 {name=M206_i_7 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 67940 60 0 0 {name=M206_i_8 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 68140 60 0 0 {name=M206_i_9 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 68500 60 0 0 {name=M206_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 71100 1370 0 0 {name=M207_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 71300 1370 0 0 {name=M207_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 71100 60 0 0 {name=M207_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 71100 210 0 0 {name=M207_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 71660 1370 0 0 {name=M208_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 71660 1220 0 0 {name=M208_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 71660 60 0 0 {name=M208_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 71860 60 0 0 {name=M208_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 72220 1370 0 0 {name=M209_i_3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 72220 1220 0 0 {name=M209_i_2 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 72420 1220 0 0 {name=M209_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 72420 1370 0 0 {name=M209_i_1 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 72220 60 0 0 {name=M209_i_7 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 72420 60 0 0 {name=M209_i_6 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 72420 210 0 0 {name=M209_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 72220 210 0 0 {name=M209_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 72780 1370 0 0 {name=M210_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 72980 1370 0 0 {name=M210_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 72780 60 0 0 {name=M210_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 72780 210 0 0 {name=M210_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16740 1370 0 0 {name=M211_i_2 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16940 1370 0 0 {name=M211_i_1 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17140 1370 0 0 {name=M211_i_0 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16740 60 0 0 {name=M211_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16740 210 0 0 {name=M211_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16740 360 0 0 {name=M211_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24580 1220 0 0 {name=M212_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24780 1220 0 0 {name=M212_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24580 1370 0 0 {name=M212_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24580 60 0 0 {name=M212_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24580 210 0 0 {name=M212_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24780 60 0 0 {name=M212_i_5 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 75580 1370 0 0 {name=M213_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 75580 1220 0 0 {name=M213_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 75780 1370 0 0 {name=M213_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 75580 210 0 0 {name=M213_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 75780 210 0 0 {name=M213_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 75580 60 0 0 {name=M213_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 76140 1070 0 0 {name=M214_i_2 L=0.6u W=0.38u nf=1 m=1 ad=1.9e-13 as=1.9e-13 pd=1.76e-06 ps=1.76e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 76140 1220 0 0 {name=M214_i_3 L=0.6u W=0.38u nf=1 m=1 ad=1.9e-13 as=1.9e-13 pd=1.76e-06 ps=1.76e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 76140 1370 0 0 {name=M214_i_4 L=0.6u W=0.38u nf=1 m=1 ad=1.9e-13 as=1.9e-13 pd=1.76e-06 ps=1.76e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 76900 1370 0 0 {name=M214_i_0 L=0.6u W=0.775u nf=1 m=1 ad=3.875e-13 as=3.875e-13 pd=2.55e-06 ps=2.55e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 76140 60 0 0 {name=M214_i_5 L=0.5u W=0.535u nf=1 m=1 ad=2.675e-13 as=2.675e-13 pd=2.07e-06 ps=2.07e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 76340 60 0 0 {name=M214_i_6 L=0.5u W=0.535u nf=1 m=1 ad=2.675e-13 as=2.675e-13 pd=2.07e-06 ps=2.07e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 76540 60 0 0 {name=M214_i_7 L=0.5u W=0.535u nf=1 m=1 ad=2.675e-13 as=2.675e-13 pd=2.07e-06 ps=2.07e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 76900 60 0 0 {name=M214_i_1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 80260 1370 0 0 {name=M215_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 80460 1370 0 0 {name=M215_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 80260 60 0 0 {name=M215_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 80260 210 0 0 {name=M215_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 80820 1370 0 0 {name=M216_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 80820 1220 0 0 {name=M216_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 80820 60 0 0 {name=M216_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 81020 60 0 0 {name=M216_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 81380 1370 0 0 {name=M217_i_3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 81380 1220 0 0 {name=M217_i_2 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 81580 1220 0 0 {name=M217_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 81580 1370 0 0 {name=M217_i_1 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 81380 60 0 0 {name=M217_i_7 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 81580 60 0 0 {name=M217_i_6 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 81580 210 0 0 {name=M217_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 81380 210 0 0 {name=M217_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 81940 1370 0 0 {name=M218_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 82140 1370 0 0 {name=M218_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 81940 60 0 0 {name=M218_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 81940 210 0 0 {name=M218_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 77260 1370 0 0 {name=M219_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 77260 1220 0 0 {name=M219_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 77260 1070 0 0 {name=M219_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 77260 60 0 0 {name=M219_i_5 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 77460 60 0 0 {name=M219_i_4 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 77660 60 0 0 {name=M219_i_3 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17500 1220 0 0 {name=M220_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17700 1220 0 0 {name=M220_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17500 1370 0 0 {name=M220_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17500 60 0 0 {name=M220_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17500 210 0 0 {name=M220_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17700 60 0 0 {name=M220_i_5 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25140 1370 0 0 {name=M221_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25140 1220 0 0 {name=M221_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25340 1370 0 0 {name=M221_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25140 210 0 0 {name=M221_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25340 210 0 0 {name=M221_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25140 60 0 0 {name=M221_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 700 1370 0 0 {name=M259_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6820 1370 0 0 {name=M259_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25700 1370 0 0 {name=M259_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25700 1220 0 0 {name=M259_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25900 1070 0 0 {name=M259_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25900 1220 0 0 {name=M259_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25900 1370 0 0 {name=M259_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27020 1370 0 0 {name=M259_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27020 1220 0 0 {name=M259_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27220 1220 0 0 {name=M259_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27220 1370 0 0 {name=M259_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26460 1370 0 0 {name=M259_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26460 1220 0 0 {name=M259_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27580 1370 0 0 {name=M259_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 700 60 0 0 {name=M259_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6820 60 0 0 {name=M259_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25700 60 0 0 {name=M259_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25700 210 0 0 {name=M259_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26100 210 0 0 {name=M259_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25900 60 0 0 {name=M259_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26100 60 0 0 {name=M259_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27020 60 0 0 {name=M259_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27020 210 0 0 {name=M259_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27220 210 0 0 {name=M259_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27220 60 0 0 {name=M259_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26460 60 0 0 {name=M259_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26660 60 0 0 {name=M259_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27580 60 0 0 {name=M259_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1060 1370 0 0 {name=M260_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7180 1370 0 0 {name=M260_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28900 1370 0 0 {name=M260_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28900 1220 0 0 {name=M260_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29100 1070 0 0 {name=M260_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29100 1220 0 0 {name=M260_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29100 1370 0 0 {name=M260_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30220 1370 0 0 {name=M260_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30220 1220 0 0 {name=M260_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30420 1220 0 0 {name=M260_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30420 1370 0 0 {name=M260_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29660 1370 0 0 {name=M260_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29660 1220 0 0 {name=M260_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30780 1370 0 0 {name=M260_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1060 60 0 0 {name=M260_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7180 60 0 0 {name=M260_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28900 60 0 0 {name=M260_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28900 210 0 0 {name=M260_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29300 210 0 0 {name=M260_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29100 60 0 0 {name=M260_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29300 60 0 0 {name=M260_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30220 60 0 0 {name=M260_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30220 210 0 0 {name=M260_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30420 210 0 0 {name=M260_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30420 60 0 0 {name=M260_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29660 60 0 0 {name=M260_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29860 60 0 0 {name=M260_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30780 60 0 0 {name=M260_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1420 1370 0 0 {name=M261_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7540 1370 0 0 {name=M261_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34140 1370 0 0 {name=M261_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34140 1220 0 0 {name=M261_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34340 1070 0 0 {name=M261_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34340 1220 0 0 {name=M261_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34340 1370 0 0 {name=M261_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35460 1370 0 0 {name=M261_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35460 1220 0 0 {name=M261_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35660 1220 0 0 {name=M261_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35660 1370 0 0 {name=M261_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34900 1370 0 0 {name=M261_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34900 1220 0 0 {name=M261_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36020 1370 0 0 {name=M261_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1420 60 0 0 {name=M261_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7540 60 0 0 {name=M261_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34140 60 0 0 {name=M261_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34140 210 0 0 {name=M261_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34540 210 0 0 {name=M261_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34340 60 0 0 {name=M261_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34540 60 0 0 {name=M261_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35460 60 0 0 {name=M261_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35460 210 0 0 {name=M261_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35660 210 0 0 {name=M261_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35660 60 0 0 {name=M261_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34900 60 0 0 {name=M261_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35100 60 0 0 {name=M261_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36020 60 0 0 {name=M261_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1780 1370 0 0 {name=M262_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7900 1370 0 0 {name=M262_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36740 1370 0 0 {name=M262_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36740 1220 0 0 {name=M262_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36940 1070 0 0 {name=M262_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36940 1220 0 0 {name=M262_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36940 1370 0 0 {name=M262_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38060 1370 0 0 {name=M262_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38060 1220 0 0 {name=M262_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38260 1220 0 0 {name=M262_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38260 1370 0 0 {name=M262_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37500 1370 0 0 {name=M262_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37500 1220 0 0 {name=M262_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38620 1370 0 0 {name=M262_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1780 60 0 0 {name=M262_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7900 60 0 0 {name=M262_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36740 60 0 0 {name=M262_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36740 210 0 0 {name=M262_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37140 210 0 0 {name=M262_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36940 60 0 0 {name=M262_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37140 60 0 0 {name=M262_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38060 60 0 0 {name=M262_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38060 210 0 0 {name=M262_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38260 210 0 0 {name=M262_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38260 60 0 0 {name=M262_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37500 60 0 0 {name=M262_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37700 60 0 0 {name=M262_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38620 60 0 0 {name=M262_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2140 1370 0 0 {name=M263_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8260 1370 0 0 {name=M263_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41020 1370 0 0 {name=M263_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41020 1220 0 0 {name=M263_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41220 1070 0 0 {name=M263_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41220 1220 0 0 {name=M263_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41220 1370 0 0 {name=M263_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41780 1370 0 0 {name=M263_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41780 1220 0 0 {name=M263_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41980 1220 0 0 {name=M263_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41980 1370 0 0 {name=M263_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39540 1370 0 0 {name=M263_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39540 1220 0 0 {name=M263_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40100 1370 0 0 {name=M263_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2140 60 0 0 {name=M263_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8260 60 0 0 {name=M263_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41020 60 0 0 {name=M263_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41020 210 0 0 {name=M263_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41420 210 0 0 {name=M263_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41220 60 0 0 {name=M263_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41420 60 0 0 {name=M263_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41780 60 0 0 {name=M263_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41780 210 0 0 {name=M263_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41980 210 0 0 {name=M263_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41980 60 0 0 {name=M263_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39540 60 0 0 {name=M263_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39740 60 0 0 {name=M263_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40100 60 0 0 {name=M263_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2500 1370 0 0 {name=M264_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8620 1370 0 0 {name=M264_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45500 1370 0 0 {name=M264_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45500 1220 0 0 {name=M264_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45700 1070 0 0 {name=M264_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45700 1220 0 0 {name=M264_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45700 1370 0 0 {name=M264_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46260 1370 0 0 {name=M264_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46260 1220 0 0 {name=M264_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46460 1220 0 0 {name=M264_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46460 1370 0 0 {name=M264_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42340 1370 0 0 {name=M264_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42340 1220 0 0 {name=M264_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42900 1370 0 0 {name=M264_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2500 60 0 0 {name=M264_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8620 60 0 0 {name=M264_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45500 60 0 0 {name=M264_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45500 210 0 0 {name=M264_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45900 210 0 0 {name=M264_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45700 60 0 0 {name=M264_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45900 60 0 0 {name=M264_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46260 60 0 0 {name=M264_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46260 210 0 0 {name=M264_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46460 210 0 0 {name=M264_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46460 60 0 0 {name=M264_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42340 60 0 0 {name=M264_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42540 60 0 0 {name=M264_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42900 60 0 0 {name=M264_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2860 1370 0 0 {name=M265_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8980 1370 0 0 {name=M265_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46820 1370 0 0 {name=M265_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46820 1220 0 0 {name=M265_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47020 1070 0 0 {name=M265_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47020 1220 0 0 {name=M265_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47020 1370 0 0 {name=M265_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48140 1370 0 0 {name=M265_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48140 1220 0 0 {name=M265_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48340 1220 0 0 {name=M265_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48340 1370 0 0 {name=M265_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47580 1370 0 0 {name=M265_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47580 1220 0 0 {name=M265_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48700 1370 0 0 {name=M265_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2860 60 0 0 {name=M265_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8980 60 0 0 {name=M265_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46820 60 0 0 {name=M265_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46820 210 0 0 {name=M265_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47220 210 0 0 {name=M265_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47020 60 0 0 {name=M265_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47220 60 0 0 {name=M265_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48140 60 0 0 {name=M265_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48140 210 0 0 {name=M265_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48340 210 0 0 {name=M265_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48340 60 0 0 {name=M265_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47580 60 0 0 {name=M265_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47780 60 0 0 {name=M265_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48700 60 0 0 {name=M265_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3220 1370 0 0 {name=M266_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9340 1370 0 0 {name=M266_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51140 1370 0 0 {name=M266_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51140 1220 0 0 {name=M266_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51340 1070 0 0 {name=M266_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51340 1220 0 0 {name=M266_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51340 1370 0 0 {name=M266_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52460 1370 0 0 {name=M266_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52460 1220 0 0 {name=M266_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52660 1220 0 0 {name=M266_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52660 1370 0 0 {name=M266_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51900 1370 0 0 {name=M266_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51900 1220 0 0 {name=M266_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53020 1370 0 0 {name=M266_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3220 60 0 0 {name=M266_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9340 60 0 0 {name=M266_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51140 60 0 0 {name=M266_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51140 210 0 0 {name=M266_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51540 210 0 0 {name=M266_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51340 60 0 0 {name=M266_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51540 60 0 0 {name=M266_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52460 60 0 0 {name=M266_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52460 210 0 0 {name=M266_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52660 210 0 0 {name=M266_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52660 60 0 0 {name=M266_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51900 60 0 0 {name=M266_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52100 60 0 0 {name=M266_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53020 60 0 0 {name=M266_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3580 1370 0 0 {name=M267_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9700 1370 0 0 {name=M267_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56700 1370 0 0 {name=M267_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56700 1220 0 0 {name=M267_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56900 1070 0 0 {name=M267_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56900 1220 0 0 {name=M267_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56900 1370 0 0 {name=M267_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57460 1370 0 0 {name=M267_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57460 1220 0 0 {name=M267_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57660 1220 0 0 {name=M267_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57660 1370 0 0 {name=M267_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54500 1370 0 0 {name=M267_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54500 1220 0 0 {name=M267_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55060 1370 0 0 {name=M267_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3580 60 0 0 {name=M267_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9700 60 0 0 {name=M267_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56700 60 0 0 {name=M267_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56700 210 0 0 {name=M267_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57100 210 0 0 {name=M267_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56900 60 0 0 {name=M267_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57100 60 0 0 {name=M267_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57460 60 0 0 {name=M267_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57460 210 0 0 {name=M267_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57660 210 0 0 {name=M267_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57660 60 0 0 {name=M267_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54500 60 0 0 {name=M267_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54700 60 0 0 {name=M267_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55060 60 0 0 {name=M267_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3940 1370 0 0 {name=M268_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10060 1370 0 0 {name=M268_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58020 1370 0 0 {name=M268_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58020 1220 0 0 {name=M268_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58220 1070 0 0 {name=M268_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58220 1220 0 0 {name=M268_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58220 1370 0 0 {name=M268_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59340 1370 0 0 {name=M268_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59340 1220 0 0 {name=M268_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59540 1220 0 0 {name=M268_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59540 1370 0 0 {name=M268_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58780 1370 0 0 {name=M268_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58780 1220 0 0 {name=M268_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59900 1370 0 0 {name=M268_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3940 60 0 0 {name=M268_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10060 60 0 0 {name=M268_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58020 60 0 0 {name=M268_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58020 210 0 0 {name=M268_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58420 210 0 0 {name=M268_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58220 60 0 0 {name=M268_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58420 60 0 0 {name=M268_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59340 60 0 0 {name=M268_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59340 210 0 0 {name=M268_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59540 210 0 0 {name=M268_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59540 60 0 0 {name=M268_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58780 60 0 0 {name=M268_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58980 60 0 0 {name=M268_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59900 60 0 0 {name=M268_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4300 1370 0 0 {name=M269_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10420 1370 0 0 {name=M269_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64740 1370 0 0 {name=M269_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64740 1220 0 0 {name=M269_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64940 1070 0 0 {name=M269_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64940 1220 0 0 {name=M269_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64940 1370 0 0 {name=M269_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 65500 1370 0 0 {name=M269_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 65500 1220 0 0 {name=M269_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 65700 1220 0 0 {name=M269_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 65700 1370 0 0 {name=M269_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61380 1370 0 0 {name=M269_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61380 1220 0 0 {name=M269_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61940 1370 0 0 {name=M269_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4300 60 0 0 {name=M269_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10420 60 0 0 {name=M269_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 64740 60 0 0 {name=M269_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 64740 210 0 0 {name=M269_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 65140 210 0 0 {name=M269_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 64940 60 0 0 {name=M269_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 65140 60 0 0 {name=M269_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 65500 60 0 0 {name=M269_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 65500 210 0 0 {name=M269_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 65700 210 0 0 {name=M269_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 65700 60 0 0 {name=M269_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61380 60 0 0 {name=M269_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61580 60 0 0 {name=M269_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61940 60 0 0 {name=M269_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4660 1370 0 0 {name=M270_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10780 1370 0 0 {name=M270_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 68860 1370 0 0 {name=M270_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 68860 1220 0 0 {name=M270_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 69060 1070 0 0 {name=M270_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 69060 1220 0 0 {name=M270_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 69060 1370 0 0 {name=M270_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 69620 1370 0 0 {name=M270_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 69620 1220 0 0 {name=M270_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 69820 1220 0 0 {name=M270_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 69820 1370 0 0 {name=M270_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 66060 1370 0 0 {name=M270_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 66060 1220 0 0 {name=M270_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 66620 1370 0 0 {name=M270_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4660 60 0 0 {name=M270_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10780 60 0 0 {name=M270_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 68860 60 0 0 {name=M270_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 68860 210 0 0 {name=M270_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 69260 210 0 0 {name=M270_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 69060 60 0 0 {name=M270_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 69260 60 0 0 {name=M270_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 69620 60 0 0 {name=M270_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 69620 210 0 0 {name=M270_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 69820 210 0 0 {name=M270_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 69820 60 0 0 {name=M270_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 66060 60 0 0 {name=M270_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 66260 60 0 0 {name=M270_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 66620 60 0 0 {name=M270_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5020 1370 0 0 {name=M271_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11140 1370 0 0 {name=M271_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 73340 1370 0 0 {name=M271_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 73340 1220 0 0 {name=M271_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 73540 1070 0 0 {name=M271_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 73540 1220 0 0 {name=M271_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 73540 1370 0 0 {name=M271_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 74100 1370 0 0 {name=M271_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 74100 1220 0 0 {name=M271_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 74300 1220 0 0 {name=M271_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 74300 1370 0 0 {name=M271_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 70180 1370 0 0 {name=M271_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 70180 1220 0 0 {name=M271_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 70740 1370 0 0 {name=M271_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5020 60 0 0 {name=M271_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11140 60 0 0 {name=M271_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 73340 60 0 0 {name=M271_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 73340 210 0 0 {name=M271_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 73740 210 0 0 {name=M271_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 73540 60 0 0 {name=M271_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 73740 60 0 0 {name=M271_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 74100 60 0 0 {name=M271_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 74100 210 0 0 {name=M271_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 74300 210 0 0 {name=M271_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 74300 60 0 0 {name=M271_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 70180 60 0 0 {name=M271_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 70380 60 0 0 {name=M271_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 70740 60 0 0 {name=M271_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5380 1370 0 0 {name=M272_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11500 1370 0 0 {name=M272_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 78020 1370 0 0 {name=M272_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 78020 1220 0 0 {name=M272_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 78220 1070 0 0 {name=M272_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 78220 1220 0 0 {name=M272_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 78220 1370 0 0 {name=M272_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 78780 1370 0 0 {name=M272_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 78780 1220 0 0 {name=M272_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 78980 1220 0 0 {name=M272_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 78980 1370 0 0 {name=M272_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 74660 1370 0 0 {name=M272_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 74660 1220 0 0 {name=M272_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 75220 1370 0 0 {name=M272_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5380 60 0 0 {name=M272_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11500 60 0 0 {name=M272_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 78020 60 0 0 {name=M272_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 78020 210 0 0 {name=M272_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 78420 210 0 0 {name=M272_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 78220 60 0 0 {name=M272_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 78420 60 0 0 {name=M272_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 78780 60 0 0 {name=M272_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 78780 210 0 0 {name=M272_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 78980 210 0 0 {name=M272_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 78980 60 0 0 {name=M272_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 74660 60 0 0 {name=M272_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 74860 60 0 0 {name=M272_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 75220 60 0 0 {name=M272_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5740 1370 0 0 {name=M273_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11860 1370 0 0 {name=M273_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 82500 1370 0 0 {name=M273_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 82500 1220 0 0 {name=M273_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 82700 1070 0 0 {name=M273_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 82700 1220 0 0 {name=M273_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 82700 1370 0 0 {name=M273_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 83260 1370 0 0 {name=M273_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 83260 1220 0 0 {name=M273_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 83460 1220 0 0 {name=M273_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 83460 1370 0 0 {name=M273_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 79340 1370 0 0 {name=M273_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 79340 1220 0 0 {name=M273_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 79900 1370 0 0 {name=M273_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5740 60 0 0 {name=M273_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11860 60 0 0 {name=M273_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 82500 60 0 0 {name=M273_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 82500 210 0 0 {name=M273_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 82900 210 0 0 {name=M273_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 82700 60 0 0 {name=M273_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 82900 60 0 0 {name=M273_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 83260 60 0 0 {name=M273_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 83260 210 0 0 {name=M273_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 83460 210 0 0 {name=M273_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 83460 60 0 0 {name=M273_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 79340 60 0 0 {name=M273_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 79540 60 0 0 {name=M273_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 79900 60 0 0 {name=M273_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6100 1370 0 0 {name=M274_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12220 1370 0 0 {name=M274_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 83820 1370 0 0 {name=M274_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 83820 1220 0 0 {name=M274_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 84020 1070 0 0 {name=M274_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 84020 1220 0 0 {name=M274_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 84020 1370 0 0 {name=M274_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 85140 1370 0 0 {name=M274_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 85140 1220 0 0 {name=M274_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 85340 1220 0 0 {name=M274_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 85340 1370 0 0 {name=M274_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 84580 1370 0 0 {name=M274_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 84580 1220 0 0 {name=M274_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 85700 1370 0 0 {name=M274_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6100 60 0 0 {name=M274_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12220 60 0 0 {name=M274_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 83820 60 0 0 {name=M274_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 83820 210 0 0 {name=M274_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 84220 210 0 0 {name=M274_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 84020 60 0 0 {name=M274_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 84220 60 0 0 {name=M274_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 85140 60 0 0 {name=M274_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 85140 210 0 0 {name=M274_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 85340 210 0 0 {name=M274_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 85340 60 0 0 {name=M274_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 84580 60 0 0 {name=M274_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 84780 60 0 0 {name=M274_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 85700 60 0 0 {name=M274_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
T {126} 36350 -35 0 0 0.3 0.3 {}
T {156} 110 -35 0 0 0.3 0.3 {}
T {171} 13510 -35 0 0 0.3 0.3 {}
T {172} 14070 -35 0 0 0.3 0.3 {}
T {173} 15190 -35 0 0 0.3 0.3 {}
T {174} 27910 -35 0 0 0.3 0.3 {}
T {175} 31110 -35 0 0 0.3 0.3 {}
T {176} 18030 -35 0 0 0.3 0.3 {}
T {177} 31670 -35 0 0 0.3 0.3 {}
T {178} 32990 -35 0 0 0.3 0.3 {}
T {179} 18590 -35 0 0 0.3 0.3 {}
T {180} 33550 -35 0 0 0.3 0.3 {}
T {181} 38950 -35 0 0 0.3 0.3 {}
T {182} 12550 -35 0 0 0.3 0.3 {}
T {183} 19510 -35 0 0 0.3 0.3 {}
T {184} 20270 -35 0 0 0.3 0.3 {}
T {185} 40430 -35 0 0 0.3 0.3 {}
T {186} 43230 -35 0 0 0.3 0.3 {}
T {187} 43990 -35 0 0 0.3 0.3 {}
T {188} 20830 -35 0 0 0.3 0.3 {}
T {189} 44550 -35 0 0 0.3 0.3 {}
T {190} 49030 -35 0 0 0.3 0.3 {}
T {191} 49990 -35 0 0 0.3 0.3 {}
T {192} 21390 -35 0 0 0.3 0.3 {}
T {193} 53350 -35 0 0 0.3 0.3 {}
T {194} 21950 -35 0 0 0.3 0.3 {}
T {195} 22510 -35 0 0 0.3 0.3 {}
T {196} 55390 -35 0 0 0.3 0.3 {}
T {197} 60230 -35 0 0 0.3 0.3 {}
T {198} 23070 -35 0 0 0.3 0.3 {}
T {199} 62270 -35 0 0 0.3 0.3 {}
T {200} 62830 -35 0 0 0.3 0.3 {}
T {201} 63590 -35 0 0 0.3 0.3 {}
T {202} 64150 -35 0 0 0.3 0.3 {}
T {203} 15950 -35 0 0 0.3 0.3 {}
T {204} 23990 -35 0 0 0.3 0.3 {}
T {205} 66950 -35 0 0 0.3 0.3 {}
T {206} 67510 -35 0 0 0.3 0.3 {}
T {207} 71070 -35 0 0 0.3 0.3 {}
T {208} 71630 -35 0 0 0.3 0.3 {}
T {209} 72190 -35 0 0 0.3 0.3 {}
T {210} 72750 -35 0 0 0.3 0.3 {}
T {211} 16710 -35 0 0 0.3 0.3 {}
T {212} 24550 -35 0 0 0.3 0.3 {}
T {213} 75550 -35 0 0 0.3 0.3 {}
T {214} 76110 -35 0 0 0.3 0.3 {}
T {215} 80230 -35 0 0 0.3 0.3 {}
T {216} 80790 -35 0 0 0.3 0.3 {}
T {217} 81350 -35 0 0 0.3 0.3 {}
T {218} 81910 -35 0 0 0.3 0.3 {}
T {219} 77230 -35 0 0 0.3 0.3 {}
T {220} 17470 -35 0 0 0.3 0.3 {}
T {221} 25110 -35 0 0 0.3 0.3 {}
T {259} 670 -35 0 0 0.3 0.3 {}
T {260} 1030 -35 0 0 0.3 0.3 {}
T {261} 1390 -35 0 0 0.3 0.3 {}
T {262} 1750 -35 0 0 0.3 0.3 {}
T {263} 2110 -35 0 0 0.3 0.3 {}
T {264} 2470 -35 0 0 0.3 0.3 {}
T {265} 2830 -35 0 0 0.3 0.3 {}
T {266} 3190 -35 0 0 0.3 0.3 {}
T {267} 3550 -35 0 0 0.3 0.3 {}
T {268} 3910 -35 0 0 0.3 0.3 {}
T {269} 4270 -35 0 0 0.3 0.3 {}
T {270} 4630 -35 0 0 0.3 0.3 {}
T {271} 4990 -35 0 0 0.3 0.3 {}
T {272} 5350 -35 0 0 0.3 0.3 {}
T {273} 5710 -35 0 0 0.3 0.3 {}
T {274} 6070 -35 0 0 0.3 0.3 {}
N 36400 1400 36400 1420 {lab=0}
C {devices/gnd.sym} 36400 1420 0 0 {name=s1 lab=0}
N 36400 1370 36430 1370 {lab=0}
C {devices/gnd.sym} 36430 1370 0 0 {name=s2 lab=0}
N 36400 30 36400 10 {lab=VDD}
C {devices/vdd.sym} 36400 10 0 0 {name=s3 lab=VDD}
N 36400 60 36430 60 {lab=VDD}
C {devices/vdd.sym} 36430 60 0 0 {name=s4 lab=VDD}
N 160 1400 160 1420 {lab=0}
C {devices/gnd.sym} 160 1420 0 0 {name=s5 lab=0}
N 160 1370 190 1370 {lab=0}
C {devices/gnd.sym} 190 1370 0 0 {name=s6 lab=0}
N 360 1400 360 1420 {lab=0}
C {devices/gnd.sym} 360 1420 0 0 {name=s7 lab=0}
N 360 1370 390 1370 {lab=0}
C {devices/gnd.sym} 390 1370 0 0 {name=s8 lab=0}
N 6480 1400 6480 1420 {lab=0}
C {devices/gnd.sym} 6480 1420 0 0 {name=s9 lab=0}
N 6480 1370 6510 1370 {lab=0}
C {devices/gnd.sym} 6510 1370 0 0 {name=s10 lab=0}
N 160 210 190 210 {lab=VDD}
C {devices/vdd.sym} 190 210 0 0 {name=s11 lab=VDD}
N 160 30 160 10 {lab=VDD}
C {devices/vdd.sym} 160 10 0 0 {name=s12 lab=VDD}
N 160 60 190 60 {lab=VDD}
C {devices/vdd.sym} 190 60 0 0 {name=s13 lab=VDD}
N 6480 30 6480 10 {lab=VDD}
C {devices/vdd.sym} 6480 10 0 0 {name=s14 lab=VDD}
N 6480 60 6510 60 {lab=VDD}
C {devices/vdd.sym} 6510 60 0 0 {name=s15 lab=VDD}
N 13560 1400 13560 1420 {lab=0}
C {devices/gnd.sym} 13560 1420 0 0 {name=s16 lab=0}
N 13560 1370 13590 1370 {lab=0}
C {devices/gnd.sym} 13590 1370 0 0 {name=s17 lab=0}
N 13560 1220 13590 1220 {lab=0}
C {devices/gnd.sym} 13590 1220 0 0 {name=s18 lab=0}
N 13760 1400 13760 1420 {lab=0}
C {devices/gnd.sym} 13760 1420 0 0 {name=s19 lab=0}
N 13760 1370 13790 1370 {lab=0}
C {devices/gnd.sym} 13790 1370 0 0 {name=s20 lab=0}
N 13560 210 13590 210 {lab=VDD}
C {devices/vdd.sym} 13590 210 0 0 {name=s21 lab=VDD}
N 13760 210 13790 210 {lab=VDD}
C {devices/vdd.sym} 13790 210 0 0 {name=s22 lab=VDD}
N 13560 30 13560 10 {lab=VDD}
C {devices/vdd.sym} 13560 10 0 0 {name=s23 lab=VDD}
N 13560 60 13590 60 {lab=VDD}
C {devices/vdd.sym} 13590 60 0 0 {name=s24 lab=VDD}
N 14120 1070 14150 1070 {lab=0}
C {devices/gnd.sym} 14150 1070 0 0 {name=s25 lab=0}
N 14120 1220 14150 1220 {lab=0}
C {devices/gnd.sym} 14150 1220 0 0 {name=s26 lab=0}
N 14120 1400 14120 1420 {lab=0}
C {devices/gnd.sym} 14120 1420 0 0 {name=s27 lab=0}
N 14120 1370 14150 1370 {lab=0}
C {devices/gnd.sym} 14150 1370 0 0 {name=s28 lab=0}
N 14880 1400 14880 1420 {lab=0}
C {devices/gnd.sym} 14880 1420 0 0 {name=s29 lab=0}
N 14880 1370 14910 1370 {lab=0}
C {devices/gnd.sym} 14910 1370 0 0 {name=s30 lab=0}
N 14120 30 14120 10 {lab=VDD}
C {devices/vdd.sym} 14120 10 0 0 {name=s31 lab=VDD}
N 14120 60 14150 60 {lab=VDD}
C {devices/vdd.sym} 14150 60 0 0 {name=s32 lab=VDD}
N 14320 30 14320 10 {lab=VDD}
C {devices/vdd.sym} 14320 10 0 0 {name=s33 lab=VDD}
N 14320 60 14350 60 {lab=VDD}
C {devices/vdd.sym} 14350 60 0 0 {name=s34 lab=VDD}
N 14520 30 14520 10 {lab=VDD}
C {devices/vdd.sym} 14520 10 0 0 {name=s35 lab=VDD}
N 14520 60 14550 60 {lab=VDD}
C {devices/vdd.sym} 14550 60 0 0 {name=s36 lab=VDD}
N 14880 30 14880 10 {lab=VDD}
C {devices/vdd.sym} 14880 10 0 0 {name=s37 lab=VDD}
N 14880 60 14910 60 {lab=VDD}
C {devices/vdd.sym} 14910 60 0 0 {name=s38 lab=VDD}
N 15240 1400 15240 1420 {lab=0}
C {devices/gnd.sym} 15240 1420 0 0 {name=s39 lab=0}
N 15240 1370 15270 1370 {lab=0}
C {devices/gnd.sym} 15270 1370 0 0 {name=s40 lab=0}
N 15440 1400 15440 1420 {lab=0}
C {devices/gnd.sym} 15440 1420 0 0 {name=s41 lab=0}
N 15440 1370 15470 1370 {lab=0}
C {devices/gnd.sym} 15470 1370 0 0 {name=s42 lab=0}
N 15640 1400 15640 1420 {lab=0}
C {devices/gnd.sym} 15640 1420 0 0 {name=s43 lab=0}
N 15640 1370 15670 1370 {lab=0}
C {devices/gnd.sym} 15670 1370 0 0 {name=s44 lab=0}
N 15240 30 15240 10 {lab=VDD}
C {devices/vdd.sym} 15240 10 0 0 {name=s45 lab=VDD}
N 15240 60 15270 60 {lab=VDD}
C {devices/vdd.sym} 15270 60 0 0 {name=s46 lab=VDD}
N 15240 210 15270 210 {lab=VDD}
C {devices/vdd.sym} 15270 210 0 0 {name=s47 lab=VDD}
N 15240 360 15270 360 {lab=VDD}
C {devices/vdd.sym} 15270 360 0 0 {name=s48 lab=VDD}
N 27960 1400 27960 1420 {lab=0}
C {devices/gnd.sym} 27960 1420 0 0 {name=s49 lab=0}
N 27960 1370 27990 1370 {lab=0}
C {devices/gnd.sym} 27990 1370 0 0 {name=s50 lab=0}
N 27960 1220 27990 1220 {lab=0}
C {devices/gnd.sym} 27990 1220 0 0 {name=s51 lab=0}
N 27960 1070 27990 1070 {lab=0}
C {devices/gnd.sym} 27990 1070 0 0 {name=s52 lab=0}
N 27960 920 27990 920 {lab=0}
C {devices/gnd.sym} 27990 920 0 0 {name=s53 lab=0}
N 27960 30 27960 10 {lab=VDD}
C {devices/vdd.sym} 27960 10 0 0 {name=s54 lab=VDD}
N 27960 60 27990 60 {lab=VDD}
C {devices/vdd.sym} 27990 60 0 0 {name=s55 lab=VDD}
N 28160 30 28160 10 {lab=VDD}
C {devices/vdd.sym} 28160 10 0 0 {name=s56 lab=VDD}
N 28160 60 28190 60 {lab=VDD}
C {devices/vdd.sym} 28190 60 0 0 {name=s57 lab=VDD}
N 28360 30 28360 10 {lab=VDD}
C {devices/vdd.sym} 28360 10 0 0 {name=s58 lab=VDD}
N 28360 60 28390 60 {lab=VDD}
C {devices/vdd.sym} 28390 60 0 0 {name=s59 lab=VDD}
N 28560 30 28560 10 {lab=VDD}
C {devices/vdd.sym} 28560 10 0 0 {name=s60 lab=VDD}
N 28560 60 28590 60 {lab=VDD}
C {devices/vdd.sym} 28590 60 0 0 {name=s61 lab=VDD}
N 31160 1220 31190 1220 {lab=0}
C {devices/gnd.sym} 31190 1220 0 0 {name=s62 lab=0}
N 31360 1220 31390 1220 {lab=0}
C {devices/gnd.sym} 31390 1220 0 0 {name=s63 lab=0}
N 31160 1400 31160 1420 {lab=0}
C {devices/gnd.sym} 31160 1420 0 0 {name=s64 lab=0}
N 31160 1370 31190 1370 {lab=0}
C {devices/gnd.sym} 31190 1370 0 0 {name=s65 lab=0}
N 31160 30 31160 10 {lab=VDD}
C {devices/vdd.sym} 31160 10 0 0 {name=s66 lab=VDD}
N 31160 60 31190 60 {lab=VDD}
C {devices/vdd.sym} 31190 60 0 0 {name=s67 lab=VDD}
N 31160 210 31190 210 {lab=VDD}
C {devices/vdd.sym} 31190 210 0 0 {name=s68 lab=VDD}
N 31360 30 31360 10 {lab=VDD}
C {devices/vdd.sym} 31360 10 0 0 {name=s69 lab=VDD}
N 31360 60 31390 60 {lab=VDD}
C {devices/vdd.sym} 31390 60 0 0 {name=s70 lab=VDD}
N 18080 1400 18080 1420 {lab=0}
C {devices/gnd.sym} 18080 1420 0 0 {name=s71 lab=0}
N 18080 1370 18110 1370 {lab=0}
C {devices/gnd.sym} 18110 1370 0 0 {name=s72 lab=0}
N 18280 1400 18280 1420 {lab=0}
C {devices/gnd.sym} 18280 1420 0 0 {name=s73 lab=0}
N 18280 1370 18310 1370 {lab=0}
C {devices/gnd.sym} 18310 1370 0 0 {name=s74 lab=0}
N 18080 30 18080 10 {lab=VDD}
C {devices/vdd.sym} 18080 10 0 0 {name=s75 lab=VDD}
N 18080 60 18110 60 {lab=VDD}
C {devices/vdd.sym} 18110 60 0 0 {name=s76 lab=VDD}
N 18080 210 18110 210 {lab=VDD}
C {devices/vdd.sym} 18110 210 0 0 {name=s77 lab=VDD}
N 31720 920 31750 920 {lab=0}
C {devices/gnd.sym} 31750 920 0 0 {name=s78 lab=0}
N 31720 1070 31750 1070 {lab=0}
C {devices/gnd.sym} 31750 1070 0 0 {name=s79 lab=0}
N 31720 1220 31750 1220 {lab=0}
C {devices/gnd.sym} 31750 1220 0 0 {name=s80 lab=0}
N 31720 1400 31720 1420 {lab=0}
C {devices/gnd.sym} 31720 1420 0 0 {name=s81 lab=0}
N 31720 1370 31750 1370 {lab=0}
C {devices/gnd.sym} 31750 1370 0 0 {name=s82 lab=0}
N 32680 1400 32680 1420 {lab=0}
C {devices/gnd.sym} 32680 1420 0 0 {name=s83 lab=0}
N 32680 1370 32710 1370 {lab=0}
C {devices/gnd.sym} 32710 1370 0 0 {name=s84 lab=0}
N 31720 30 31720 10 {lab=VDD}
C {devices/vdd.sym} 31720 10 0 0 {name=s85 lab=VDD}
N 31720 60 31750 60 {lab=VDD}
C {devices/vdd.sym} 31750 60 0 0 {name=s86 lab=VDD}
N 31920 30 31920 10 {lab=VDD}
C {devices/vdd.sym} 31920 10 0 0 {name=s87 lab=VDD}
N 31920 60 31950 60 {lab=VDD}
C {devices/vdd.sym} 31950 60 0 0 {name=s88 lab=VDD}
N 32120 30 32120 10 {lab=VDD}
C {devices/vdd.sym} 32120 10 0 0 {name=s89 lab=VDD}
N 32120 60 32150 60 {lab=VDD}
C {devices/vdd.sym} 32150 60 0 0 {name=s90 lab=VDD}
N 32320 30 32320 10 {lab=VDD}
C {devices/vdd.sym} 32320 10 0 0 {name=s91 lab=VDD}
N 32320 60 32350 60 {lab=VDD}
C {devices/vdd.sym} 32350 60 0 0 {name=s92 lab=VDD}
N 32680 30 32680 10 {lab=VDD}
C {devices/vdd.sym} 32680 10 0 0 {name=s93 lab=VDD}
N 32680 60 32710 60 {lab=VDD}
C {devices/vdd.sym} 32710 60 0 0 {name=s94 lab=VDD}
N 33040 1400 33040 1420 {lab=0}
C {devices/gnd.sym} 33040 1420 0 0 {name=s95 lab=0}
N 33040 1370 33070 1370 {lab=0}
C {devices/gnd.sym} 33070 1370 0 0 {name=s96 lab=0}
N 33040 1220 33070 1220 {lab=0}
C {devices/gnd.sym} 33070 1220 0 0 {name=s97 lab=0}
N 33240 1220 33270 1220 {lab=0}
C {devices/gnd.sym} 33270 1220 0 0 {name=s98 lab=0}
N 33240 1400 33240 1420 {lab=0}
C {devices/gnd.sym} 33240 1420 0 0 {name=s99 lab=0}
N 33240 1370 33270 1370 {lab=0}
C {devices/gnd.sym} 33270 1370 0 0 {name=s100 lab=0}
N 33040 30 33040 10 {lab=VDD}
C {devices/vdd.sym} 33040 10 0 0 {name=s101 lab=VDD}
N 33040 60 33070 60 {lab=VDD}
C {devices/vdd.sym} 33070 60 0 0 {name=s102 lab=VDD}
N 33240 30 33240 10 {lab=VDD}
C {devices/vdd.sym} 33240 10 0 0 {name=s103 lab=VDD}
N 33240 60 33270 60 {lab=VDD}
C {devices/vdd.sym} 33270 60 0 0 {name=s104 lab=VDD}
N 33240 210 33270 210 {lab=VDD}
C {devices/vdd.sym} 33270 210 0 0 {name=s105 lab=VDD}
N 33040 210 33070 210 {lab=VDD}
C {devices/vdd.sym} 33070 210 0 0 {name=s106 lab=VDD}
N 18640 1220 18670 1220 {lab=0}
C {devices/gnd.sym} 18670 1220 0 0 {name=s107 lab=0}
N 18640 1400 18640 1420 {lab=0}
C {devices/gnd.sym} 18640 1420 0 0 {name=s108 lab=0}
N 18640 1370 18670 1370 {lab=0}
C {devices/gnd.sym} 18670 1370 0 0 {name=s109 lab=0}
N 19200 1400 19200 1420 {lab=0}
C {devices/gnd.sym} 19200 1420 0 0 {name=s110 lab=0}
N 19200 1370 19230 1370 {lab=0}
C {devices/gnd.sym} 19230 1370 0 0 {name=s111 lab=0}
N 18640 30 18640 10 {lab=VDD}
C {devices/vdd.sym} 18640 10 0 0 {name=s112 lab=VDD}
N 18640 60 18670 60 {lab=VDD}
C {devices/vdd.sym} 18670 60 0 0 {name=s113 lab=VDD}
N 18840 30 18840 10 {lab=VDD}
C {devices/vdd.sym} 18840 10 0 0 {name=s114 lab=VDD}
N 18840 60 18870 60 {lab=VDD}
C {devices/vdd.sym} 18870 60 0 0 {name=s115 lab=VDD}
N 19200 30 19200 10 {lab=VDD}
C {devices/vdd.sym} 19200 10 0 0 {name=s116 lab=VDD}
N 19200 60 19230 60 {lab=VDD}
C {devices/vdd.sym} 19230 60 0 0 {name=s117 lab=VDD}
N 33600 1400 33600 1420 {lab=0}
C {devices/gnd.sym} 33600 1420 0 0 {name=s118 lab=0}
N 33600 1370 33630 1370 {lab=0}
C {devices/gnd.sym} 33630 1370 0 0 {name=s119 lab=0}
N 33600 1220 33630 1220 {lab=0}
C {devices/gnd.sym} 33630 1220 0 0 {name=s120 lab=0}
N 33800 1400 33800 1420 {lab=0}
C {devices/gnd.sym} 33800 1420 0 0 {name=s121 lab=0}
N 33800 1370 33830 1370 {lab=0}
C {devices/gnd.sym} 33830 1370 0 0 {name=s122 lab=0}
N 33600 210 33630 210 {lab=VDD}
C {devices/vdd.sym} 33630 210 0 0 {name=s123 lab=VDD}
N 33800 210 33830 210 {lab=VDD}
C {devices/vdd.sym} 33830 210 0 0 {name=s124 lab=VDD}
N 33600 30 33600 10 {lab=VDD}
C {devices/vdd.sym} 33600 10 0 0 {name=s125 lab=VDD}
N 33600 60 33630 60 {lab=VDD}
C {devices/vdd.sym} 33630 60 0 0 {name=s126 lab=VDD}
N 39000 1400 39000 1420 {lab=0}
C {devices/gnd.sym} 39000 1420 0 0 {name=s127 lab=0}
N 39000 1370 39030 1370 {lab=0}
C {devices/gnd.sym} 39030 1370 0 0 {name=s128 lab=0}
N 39000 1220 39030 1220 {lab=0}
C {devices/gnd.sym} 39030 1220 0 0 {name=s129 lab=0}
N 39000 30 39000 10 {lab=VDD}
C {devices/vdd.sym} 39000 10 0 0 {name=s130 lab=VDD}
N 39000 60 39030 60 {lab=VDD}
C {devices/vdd.sym} 39030 60 0 0 {name=s131 lab=VDD}
N 39200 30 39200 10 {lab=VDD}
C {devices/vdd.sym} 39200 10 0 0 {name=s132 lab=VDD}
N 39200 60 39230 60 {lab=VDD}
C {devices/vdd.sym} 39230 60 0 0 {name=s133 lab=VDD}
N 12600 1400 12600 1420 {lab=0}
C {devices/gnd.sym} 12600 1420 0 0 {name=s134 lab=0}
N 12600 1370 12630 1370 {lab=0}
C {devices/gnd.sym} 12630 1370 0 0 {name=s135 lab=0}
N 12800 1400 12800 1420 {lab=0}
C {devices/gnd.sym} 12800 1420 0 0 {name=s136 lab=0}
N 12800 1370 12830 1370 {lab=0}
C {devices/gnd.sym} 12830 1370 0 0 {name=s137 lab=0}
N 13000 1400 13000 1420 {lab=0}
C {devices/gnd.sym} 13000 1420 0 0 {name=s138 lab=0}
N 13000 1370 13030 1370 {lab=0}
C {devices/gnd.sym} 13030 1370 0 0 {name=s139 lab=0}
N 13200 1400 13200 1420 {lab=0}
C {devices/gnd.sym} 13200 1420 0 0 {name=s140 lab=0}
N 13200 1370 13230 1370 {lab=0}
C {devices/gnd.sym} 13230 1370 0 0 {name=s141 lab=0}
N 12600 30 12600 10 {lab=VDD}
C {devices/vdd.sym} 12600 10 0 0 {name=s142 lab=VDD}
N 12600 60 12630 60 {lab=VDD}
C {devices/vdd.sym} 12630 60 0 0 {name=s143 lab=VDD}
N 12600 210 12630 210 {lab=VDD}
C {devices/vdd.sym} 12630 210 0 0 {name=s144 lab=VDD}
N 12600 360 12630 360 {lab=VDD}
C {devices/vdd.sym} 12630 360 0 0 {name=s145 lab=VDD}
N 12600 510 12630 510 {lab=VDD}
C {devices/vdd.sym} 12630 510 0 0 {name=s146 lab=VDD}
N 19560 1400 19560 1420 {lab=0}
C {devices/gnd.sym} 19560 1420 0 0 {name=s147 lab=0}
N 19560 1370 19590 1370 {lab=0}
C {devices/gnd.sym} 19590 1370 0 0 {name=s148 lab=0}
N 19760 1400 19760 1420 {lab=0}
C {devices/gnd.sym} 19760 1420 0 0 {name=s149 lab=0}
N 19760 1370 19790 1370 {lab=0}
C {devices/gnd.sym} 19790 1370 0 0 {name=s150 lab=0}
N 19960 1400 19960 1420 {lab=0}
C {devices/gnd.sym} 19960 1420 0 0 {name=s151 lab=0}
N 19960 1370 19990 1370 {lab=0}
C {devices/gnd.sym} 19990 1370 0 0 {name=s152 lab=0}
N 19560 30 19560 10 {lab=VDD}
C {devices/vdd.sym} 19560 10 0 0 {name=s153 lab=VDD}
N 19560 60 19590 60 {lab=VDD}
C {devices/vdd.sym} 19590 60 0 0 {name=s154 lab=VDD}
N 19560 210 19590 210 {lab=VDD}
C {devices/vdd.sym} 19590 210 0 0 {name=s155 lab=VDD}
N 19560 360 19590 360 {lab=VDD}
C {devices/vdd.sym} 19590 360 0 0 {name=s156 lab=VDD}
N 20320 1220 20350 1220 {lab=0}
C {devices/gnd.sym} 20350 1220 0 0 {name=s157 lab=0}
N 20520 1220 20550 1220 {lab=0}
C {devices/gnd.sym} 20550 1220 0 0 {name=s158 lab=0}
N 20320 1400 20320 1420 {lab=0}
C {devices/gnd.sym} 20320 1420 0 0 {name=s159 lab=0}
N 20320 1370 20350 1370 {lab=0}
C {devices/gnd.sym} 20350 1370 0 0 {name=s160 lab=0}
N 20320 30 20320 10 {lab=VDD}
C {devices/vdd.sym} 20320 10 0 0 {name=s161 lab=VDD}
N 20320 60 20350 60 {lab=VDD}
C {devices/vdd.sym} 20350 60 0 0 {name=s162 lab=VDD}
N 20320 210 20350 210 {lab=VDD}
C {devices/vdd.sym} 20350 210 0 0 {name=s163 lab=VDD}
N 20520 30 20520 10 {lab=VDD}
C {devices/vdd.sym} 20520 10 0 0 {name=s164 lab=VDD}
N 20520 60 20550 60 {lab=VDD}
C {devices/vdd.sym} 20550 60 0 0 {name=s165 lab=VDD}
N 40480 1400 40480 1420 {lab=0}
C {devices/gnd.sym} 40480 1420 0 0 {name=s166 lab=0}
N 40480 1370 40510 1370 {lab=0}
C {devices/gnd.sym} 40510 1370 0 0 {name=s167 lab=0}
N 40480 1220 40510 1220 {lab=0}
C {devices/gnd.sym} 40510 1220 0 0 {name=s168 lab=0}
N 40680 1400 40680 1420 {lab=0}
C {devices/gnd.sym} 40680 1420 0 0 {name=s169 lab=0}
N 40680 1370 40710 1370 {lab=0}
C {devices/gnd.sym} 40710 1370 0 0 {name=s170 lab=0}
N 40480 210 40510 210 {lab=VDD}
C {devices/vdd.sym} 40510 210 0 0 {name=s171 lab=VDD}
N 40680 210 40710 210 {lab=VDD}
C {devices/vdd.sym} 40710 210 0 0 {name=s172 lab=VDD}
N 40480 30 40480 10 {lab=VDD}
C {devices/vdd.sym} 40480 10 0 0 {name=s173 lab=VDD}
N 40480 60 40510 60 {lab=VDD}
C {devices/vdd.sym} 40510 60 0 0 {name=s174 lab=VDD}
N 43280 1400 43280 1420 {lab=0}
C {devices/gnd.sym} 43280 1420 0 0 {name=s175 lab=0}
N 43280 1370 43310 1370 {lab=0}
C {devices/gnd.sym} 43310 1370 0 0 {name=s176 lab=0}
N 43280 1220 43310 1220 {lab=0}
C {devices/gnd.sym} 43310 1220 0 0 {name=s177 lab=0}
N 43280 1070 43310 1070 {lab=0}
C {devices/gnd.sym} 43310 1070 0 0 {name=s178 lab=0}
N 43280 30 43280 10 {lab=VDD}
C {devices/vdd.sym} 43280 10 0 0 {name=s179 lab=VDD}
N 43280 60 43310 60 {lab=VDD}
C {devices/vdd.sym} 43310 60 0 0 {name=s180 lab=VDD}
N 43480 30 43480 10 {lab=VDD}
C {devices/vdd.sym} 43480 10 0 0 {name=s181 lab=VDD}
N 43480 60 43510 60 {lab=VDD}
C {devices/vdd.sym} 43510 60 0 0 {name=s182 lab=VDD}
N 43680 30 43680 10 {lab=VDD}
C {devices/vdd.sym} 43680 10 0 0 {name=s183 lab=VDD}
N 43680 60 43710 60 {lab=VDD}
C {devices/vdd.sym} 43710 60 0 0 {name=s184 lab=VDD}
N 44040 1400 44040 1420 {lab=0}
C {devices/gnd.sym} 44040 1420 0 0 {name=s185 lab=0}
N 44040 1370 44070 1370 {lab=0}
C {devices/gnd.sym} 44070 1370 0 0 {name=s186 lab=0}
N 44040 1220 44070 1220 {lab=0}
C {devices/gnd.sym} 44070 1220 0 0 {name=s187 lab=0}
N 44240 1400 44240 1420 {lab=0}
C {devices/gnd.sym} 44240 1420 0 0 {name=s188 lab=0}
N 44240 1370 44270 1370 {lab=0}
C {devices/gnd.sym} 44270 1370 0 0 {name=s189 lab=0}
N 44040 210 44070 210 {lab=VDD}
C {devices/vdd.sym} 44070 210 0 0 {name=s190 lab=VDD}
N 44240 210 44270 210 {lab=VDD}
C {devices/vdd.sym} 44270 210 0 0 {name=s191 lab=VDD}
N 44040 30 44040 10 {lab=VDD}
C {devices/vdd.sym} 44040 10 0 0 {name=s192 lab=VDD}
N 44040 60 44070 60 {lab=VDD}
C {devices/vdd.sym} 44070 60 0 0 {name=s193 lab=VDD}
N 20880 1400 20880 1420 {lab=0}
C {devices/gnd.sym} 20880 1420 0 0 {name=s194 lab=0}
N 20880 1370 20910 1370 {lab=0}
C {devices/gnd.sym} 20910 1370 0 0 {name=s195 lab=0}
N 21080 1400 21080 1420 {lab=0}
C {devices/gnd.sym} 21080 1420 0 0 {name=s196 lab=0}
N 21080 1370 21110 1370 {lab=0}
C {devices/gnd.sym} 21110 1370 0 0 {name=s197 lab=0}
N 20880 30 20880 10 {lab=VDD}
C {devices/vdd.sym} 20880 10 0 0 {name=s198 lab=VDD}
N 20880 60 20910 60 {lab=VDD}
C {devices/vdd.sym} 20910 60 0 0 {name=s199 lab=VDD}
N 20880 210 20910 210 {lab=VDD}
C {devices/vdd.sym} 20910 210 0 0 {name=s200 lab=VDD}
N 44600 1220 44630 1220 {lab=0}
C {devices/gnd.sym} 44630 1220 0 0 {name=s201 lab=0}
N 44600 1400 44600 1420 {lab=0}
C {devices/gnd.sym} 44600 1420 0 0 {name=s202 lab=0}
N 44600 1370 44630 1370 {lab=0}
C {devices/gnd.sym} 44630 1370 0 0 {name=s203 lab=0}
N 45160 1400 45160 1420 {lab=0}
C {devices/gnd.sym} 45160 1420 0 0 {name=s204 lab=0}
N 45160 1370 45190 1370 {lab=0}
C {devices/gnd.sym} 45190 1370 0 0 {name=s205 lab=0}
N 44600 30 44600 10 {lab=VDD}
C {devices/vdd.sym} 44600 10 0 0 {name=s206 lab=VDD}
N 44600 60 44630 60 {lab=VDD}
C {devices/vdd.sym} 44630 60 0 0 {name=s207 lab=VDD}
N 44800 30 44800 10 {lab=VDD}
C {devices/vdd.sym} 44800 10 0 0 {name=s208 lab=VDD}
N 44800 60 44830 60 {lab=VDD}
C {devices/vdd.sym} 44830 60 0 0 {name=s209 lab=VDD}
N 45160 30 45160 10 {lab=VDD}
C {devices/vdd.sym} 45160 10 0 0 {name=s210 lab=VDD}
N 45160 60 45190 60 {lab=VDD}
C {devices/vdd.sym} 45190 60 0 0 {name=s211 lab=VDD}
N 49080 1400 49080 1420 {lab=0}
C {devices/gnd.sym} 49080 1420 0 0 {name=s212 lab=0}
N 49080 1370 49110 1370 {lab=0}
C {devices/gnd.sym} 49110 1370 0 0 {name=s213 lab=0}
N 49080 1220 49110 1220 {lab=0}
C {devices/gnd.sym} 49110 1220 0 0 {name=s214 lab=0}
N 49080 1070 49110 1070 {lab=0}
C {devices/gnd.sym} 49110 1070 0 0 {name=s215 lab=0}
N 49080 920 49110 920 {lab=0}
C {devices/gnd.sym} 49110 920 0 0 {name=s216 lab=0}
N 49080 30 49080 10 {lab=VDD}
C {devices/vdd.sym} 49080 10 0 0 {name=s217 lab=VDD}
N 49080 60 49110 60 {lab=VDD}
C {devices/vdd.sym} 49110 60 0 0 {name=s218 lab=VDD}
N 49280 30 49280 10 {lab=VDD}
C {devices/vdd.sym} 49280 10 0 0 {name=s219 lab=VDD}
N 49280 60 49310 60 {lab=VDD}
C {devices/vdd.sym} 49310 60 0 0 {name=s220 lab=VDD}
N 49480 30 49480 10 {lab=VDD}
C {devices/vdd.sym} 49480 10 0 0 {name=s221 lab=VDD}
N 49480 60 49510 60 {lab=VDD}
C {devices/vdd.sym} 49510 60 0 0 {name=s222 lab=VDD}
N 49680 30 49680 10 {lab=VDD}
C {devices/vdd.sym} 49680 10 0 0 {name=s223 lab=VDD}
N 49680 60 49710 60 {lab=VDD}
C {devices/vdd.sym} 49710 60 0 0 {name=s224 lab=VDD}
N 50040 1400 50040 1420 {lab=0}
C {devices/gnd.sym} 50040 1420 0 0 {name=s225 lab=0}
N 50040 1370 50070 1370 {lab=0}
C {devices/gnd.sym} 50070 1370 0 0 {name=s226 lab=0}
N 50240 1400 50240 1420 {lab=0}
C {devices/gnd.sym} 50240 1420 0 0 {name=s227 lab=0}
N 50240 1370 50270 1370 {lab=0}
C {devices/gnd.sym} 50270 1370 0 0 {name=s228 lab=0}
N 50600 1400 50600 1420 {lab=0}
C {devices/gnd.sym} 50600 1420 0 0 {name=s229 lab=0}
N 50600 1370 50630 1370 {lab=0}
C {devices/gnd.sym} 50630 1370 0 0 {name=s230 lab=0}
N 50600 1220 50630 1220 {lab=0}
C {devices/gnd.sym} 50630 1220 0 0 {name=s231 lab=0}
N 50800 1400 50800 1420 {lab=0}
C {devices/gnd.sym} 50800 1420 0 0 {name=s232 lab=0}
N 50800 1370 50830 1370 {lab=0}
C {devices/gnd.sym} 50830 1370 0 0 {name=s233 lab=0}
N 50040 210 50070 210 {lab=VDD}
C {devices/vdd.sym} 50070 210 0 0 {name=s234 lab=VDD}
N 50040 30 50040 10 {lab=VDD}
C {devices/vdd.sym} 50040 10 0 0 {name=s235 lab=VDD}
N 50040 60 50070 60 {lab=VDD}
C {devices/vdd.sym} 50070 60 0 0 {name=s236 lab=VDD}
N 50600 30 50600 10 {lab=VDD}
C {devices/vdd.sym} 50600 10 0 0 {name=s237 lab=VDD}
N 50600 60 50630 60 {lab=VDD}
C {devices/vdd.sym} 50630 60 0 0 {name=s238 lab=VDD}
N 50600 210 50630 210 {lab=VDD}
C {devices/vdd.sym} 50630 210 0 0 {name=s239 lab=VDD}
N 50800 210 50830 210 {lab=VDD}
C {devices/vdd.sym} 50830 210 0 0 {name=s240 lab=VDD}
N 21440 1400 21440 1420 {lab=0}
C {devices/gnd.sym} 21440 1420 0 0 {name=s241 lab=0}
N 21440 1370 21470 1370 {lab=0}
C {devices/gnd.sym} 21470 1370 0 0 {name=s242 lab=0}
N 21640 1400 21640 1420 {lab=0}
C {devices/gnd.sym} 21640 1420 0 0 {name=s243 lab=0}
N 21640 1370 21670 1370 {lab=0}
C {devices/gnd.sym} 21670 1370 0 0 {name=s244 lab=0}
N 21440 30 21440 10 {lab=VDD}
C {devices/vdd.sym} 21440 10 0 0 {name=s245 lab=VDD}
N 21440 60 21470 60 {lab=VDD}
C {devices/vdd.sym} 21470 60 0 0 {name=s246 lab=VDD}
N 21440 210 21470 210 {lab=VDD}
C {devices/vdd.sym} 21470 210 0 0 {name=s247 lab=VDD}
N 53400 1400 53400 1420 {lab=0}
C {devices/gnd.sym} 53400 1420 0 0 {name=s248 lab=0}
N 53400 1370 53430 1370 {lab=0}
C {devices/gnd.sym} 53430 1370 0 0 {name=s249 lab=0}
N 53600 1400 53600 1420 {lab=0}
C {devices/gnd.sym} 53600 1420 0 0 {name=s250 lab=0}
N 53600 1370 53630 1370 {lab=0}
C {devices/gnd.sym} 53630 1370 0 0 {name=s251 lab=0}
N 53960 1400 53960 1420 {lab=0}
C {devices/gnd.sym} 53960 1420 0 0 {name=s252 lab=0}
N 53960 1370 53990 1370 {lab=0}
C {devices/gnd.sym} 53990 1370 0 0 {name=s253 lab=0}
N 53960 1220 53990 1220 {lab=0}
C {devices/gnd.sym} 53990 1220 0 0 {name=s254 lab=0}
N 54160 1400 54160 1420 {lab=0}
C {devices/gnd.sym} 54160 1420 0 0 {name=s255 lab=0}
N 54160 1370 54190 1370 {lab=0}
C {devices/gnd.sym} 54190 1370 0 0 {name=s256 lab=0}
N 53400 210 53430 210 {lab=VDD}
C {devices/vdd.sym} 53430 210 0 0 {name=s257 lab=VDD}
N 53400 30 53400 10 {lab=VDD}
C {devices/vdd.sym} 53400 10 0 0 {name=s258 lab=VDD}
N 53400 60 53430 60 {lab=VDD}
C {devices/vdd.sym} 53430 60 0 0 {name=s259 lab=VDD}
N 53960 30 53960 10 {lab=VDD}
C {devices/vdd.sym} 53960 10 0 0 {name=s260 lab=VDD}
N 53960 60 53990 60 {lab=VDD}
C {devices/vdd.sym} 53990 60 0 0 {name=s261 lab=VDD}
N 53960 210 53990 210 {lab=VDD}
C {devices/vdd.sym} 53990 210 0 0 {name=s262 lab=VDD}
N 54160 210 54190 210 {lab=VDD}
C {devices/vdd.sym} 54190 210 0 0 {name=s263 lab=VDD}
N 22000 1400 22000 1420 {lab=0}
C {devices/gnd.sym} 22000 1420 0 0 {name=s264 lab=0}
N 22000 1370 22030 1370 {lab=0}
C {devices/gnd.sym} 22030 1370 0 0 {name=s265 lab=0}
N 22200 1400 22200 1420 {lab=0}
C {devices/gnd.sym} 22200 1420 0 0 {name=s266 lab=0}
N 22200 1370 22230 1370 {lab=0}
C {devices/gnd.sym} 22230 1370 0 0 {name=s267 lab=0}
N 22000 30 22000 10 {lab=VDD}
C {devices/vdd.sym} 22000 10 0 0 {name=s268 lab=VDD}
N 22000 60 22030 60 {lab=VDD}
C {devices/vdd.sym} 22030 60 0 0 {name=s269 lab=VDD}
N 22000 210 22030 210 {lab=VDD}
C {devices/vdd.sym} 22030 210 0 0 {name=s270 lab=VDD}
N 22560 1400 22560 1420 {lab=0}
C {devices/gnd.sym} 22560 1420 0 0 {name=s271 lab=0}
N 22560 1370 22590 1370 {lab=0}
C {devices/gnd.sym} 22590 1370 0 0 {name=s272 lab=0}
N 22560 1220 22590 1220 {lab=0}
C {devices/gnd.sym} 22590 1220 0 0 {name=s273 lab=0}
N 22560 30 22560 10 {lab=VDD}
C {devices/vdd.sym} 22560 10 0 0 {name=s274 lab=VDD}
N 22560 60 22590 60 {lab=VDD}
C {devices/vdd.sym} 22590 60 0 0 {name=s275 lab=VDD}
N 22760 30 22760 10 {lab=VDD}
C {devices/vdd.sym} 22760 10 0 0 {name=s276 lab=VDD}
N 22760 60 22790 60 {lab=VDD}
C {devices/vdd.sym} 22790 60 0 0 {name=s277 lab=VDD}
N 56360 1400 56360 1420 {lab=0}
C {devices/gnd.sym} 56360 1420 0 0 {name=s278 lab=0}
N 56360 1370 56390 1370 {lab=0}
C {devices/gnd.sym} 56390 1370 0 0 {name=s279 lab=0}
N 55800 1400 55800 1420 {lab=0}
C {devices/gnd.sym} 55800 1420 0 0 {name=s280 lab=0}
N 55800 1370 55830 1370 {lab=0}
C {devices/gnd.sym} 55830 1370 0 0 {name=s281 lab=0}
N 55800 1220 55830 1220 {lab=0}
C {devices/gnd.sym} 55830 1220 0 0 {name=s282 lab=0}
N 56000 1220 56030 1220 {lab=0}
C {devices/gnd.sym} 56030 1220 0 0 {name=s283 lab=0}
N 56000 1400 56000 1420 {lab=0}
C {devices/gnd.sym} 56000 1420 0 0 {name=s284 lab=0}
N 56000 1370 56030 1370 {lab=0}
C {devices/gnd.sym} 56030 1370 0 0 {name=s285 lab=0}
N 55440 1400 55440 1420 {lab=0}
C {devices/gnd.sym} 55440 1420 0 0 {name=s286 lab=0}
N 55440 1370 55470 1370 {lab=0}
C {devices/gnd.sym} 55470 1370 0 0 {name=s287 lab=0}
N 56360 30 56360 10 {lab=VDD}
C {devices/vdd.sym} 56360 10 0 0 {name=s288 lab=VDD}
N 56360 60 56390 60 {lab=VDD}
C {devices/vdd.sym} 56390 60 0 0 {name=s289 lab=VDD}
N 55800 30 55800 10 {lab=VDD}
C {devices/vdd.sym} 55800 10 0 0 {name=s290 lab=VDD}
N 55800 60 55830 60 {lab=VDD}
C {devices/vdd.sym} 55830 60 0 0 {name=s291 lab=VDD}
N 55800 210 55830 210 {lab=VDD}
C {devices/vdd.sym} 55830 210 0 0 {name=s292 lab=VDD}
N 56000 210 56030 210 {lab=VDD}
C {devices/vdd.sym} 56030 210 0 0 {name=s293 lab=VDD}
N 56000 30 56000 10 {lab=VDD}
C {devices/vdd.sym} 56000 10 0 0 {name=s294 lab=VDD}
N 56000 60 56030 60 {lab=VDD}
C {devices/vdd.sym} 56030 60 0 0 {name=s295 lab=VDD}
N 55440 30 55440 10 {lab=VDD}
C {devices/vdd.sym} 55440 10 0 0 {name=s296 lab=VDD}
N 55440 60 55470 60 {lab=VDD}
C {devices/vdd.sym} 55470 60 0 0 {name=s297 lab=VDD}
N 60280 1220 60310 1220 {lab=0}
C {devices/gnd.sym} 60310 1220 0 0 {name=s298 lab=0}
N 60280 1400 60280 1420 {lab=0}
C {devices/gnd.sym} 60280 1420 0 0 {name=s299 lab=0}
N 60280 1370 60310 1370 {lab=0}
C {devices/gnd.sym} 60310 1370 0 0 {name=s300 lab=0}
N 60840 1400 60840 1420 {lab=0}
C {devices/gnd.sym} 60840 1420 0 0 {name=s301 lab=0}
N 60840 1370 60870 1370 {lab=0}
C {devices/gnd.sym} 60870 1370 0 0 {name=s302 lab=0}
N 60840 1220 60870 1220 {lab=0}
C {devices/gnd.sym} 60870 1220 0 0 {name=s303 lab=0}
N 61040 1220 61070 1220 {lab=0}
C {devices/gnd.sym} 61070 1220 0 0 {name=s304 lab=0}
N 60280 30 60280 10 {lab=VDD}
C {devices/vdd.sym} 60280 10 0 0 {name=s305 lab=VDD}
N 60280 60 60310 60 {lab=VDD}
C {devices/vdd.sym} 60310 60 0 0 {name=s306 lab=VDD}
N 60480 30 60480 10 {lab=VDD}
C {devices/vdd.sym} 60480 10 0 0 {name=s307 lab=VDD}
N 60480 60 60510 60 {lab=VDD}
C {devices/vdd.sym} 60510 60 0 0 {name=s308 lab=VDD}
N 60840 30 60840 10 {lab=VDD}
C {devices/vdd.sym} 60840 10 0 0 {name=s309 lab=VDD}
N 60840 60 60870 60 {lab=VDD}
C {devices/vdd.sym} 60870 60 0 0 {name=s310 lab=VDD}
N 60840 210 60870 210 {lab=VDD}
C {devices/vdd.sym} 60870 210 0 0 {name=s311 lab=VDD}
N 61040 30 61040 10 {lab=VDD}
C {devices/vdd.sym} 61040 10 0 0 {name=s312 lab=VDD}
N 61040 60 61070 60 {lab=VDD}
C {devices/vdd.sym} 61070 60 0 0 {name=s313 lab=VDD}
N 23120 1220 23150 1220 {lab=0}
C {devices/gnd.sym} 23150 1220 0 0 {name=s314 lab=0}
N 23120 1400 23120 1420 {lab=0}
C {devices/gnd.sym} 23120 1420 0 0 {name=s315 lab=0}
N 23120 1370 23150 1370 {lab=0}
C {devices/gnd.sym} 23150 1370 0 0 {name=s316 lab=0}
N 23680 1400 23680 1420 {lab=0}
C {devices/gnd.sym} 23680 1420 0 0 {name=s317 lab=0}
N 23680 1370 23710 1370 {lab=0}
C {devices/gnd.sym} 23710 1370 0 0 {name=s318 lab=0}
N 23120 30 23120 10 {lab=VDD}
C {devices/vdd.sym} 23120 10 0 0 {name=s319 lab=VDD}
N 23120 60 23150 60 {lab=VDD}
C {devices/vdd.sym} 23150 60 0 0 {name=s320 lab=VDD}
N 23320 30 23320 10 {lab=VDD}
C {devices/vdd.sym} 23320 10 0 0 {name=s321 lab=VDD}
N 23320 60 23350 60 {lab=VDD}
C {devices/vdd.sym} 23350 60 0 0 {name=s322 lab=VDD}
N 23680 30 23680 10 {lab=VDD}
C {devices/vdd.sym} 23680 10 0 0 {name=s323 lab=VDD}
N 23680 60 23710 60 {lab=VDD}
C {devices/vdd.sym} 23710 60 0 0 {name=s324 lab=VDD}
N 62320 1400 62320 1420 {lab=0}
C {devices/gnd.sym} 62320 1420 0 0 {name=s325 lab=0}
N 62320 1370 62350 1370 {lab=0}
C {devices/gnd.sym} 62350 1370 0 0 {name=s326 lab=0}
N 62320 1220 62350 1220 {lab=0}
C {devices/gnd.sym} 62350 1220 0 0 {name=s327 lab=0}
N 62520 1400 62520 1420 {lab=0}
C {devices/gnd.sym} 62520 1420 0 0 {name=s328 lab=0}
N 62520 1370 62550 1370 {lab=0}
C {devices/gnd.sym} 62550 1370 0 0 {name=s329 lab=0}
N 62320 210 62350 210 {lab=VDD}
C {devices/vdd.sym} 62350 210 0 0 {name=s330 lab=VDD}
N 62520 210 62550 210 {lab=VDD}
C {devices/vdd.sym} 62550 210 0 0 {name=s331 lab=VDD}
N 62320 30 62320 10 {lab=VDD}
C {devices/vdd.sym} 62320 10 0 0 {name=s332 lab=VDD}
N 62320 60 62350 60 {lab=VDD}
C {devices/vdd.sym} 62350 60 0 0 {name=s333 lab=VDD}
N 62880 1400 62880 1420 {lab=0}
C {devices/gnd.sym} 62880 1420 0 0 {name=s334 lab=0}
N 62880 1370 62910 1370 {lab=0}
C {devices/gnd.sym} 62910 1370 0 0 {name=s335 lab=0}
N 62880 1220 62910 1220 {lab=0}
C {devices/gnd.sym} 62910 1220 0 0 {name=s336 lab=0}
N 62880 1070 62910 1070 {lab=0}
C {devices/gnd.sym} 62910 1070 0 0 {name=s337 lab=0}
N 62880 30 62880 10 {lab=VDD}
C {devices/vdd.sym} 62880 10 0 0 {name=s338 lab=VDD}
N 62880 60 62910 60 {lab=VDD}
C {devices/vdd.sym} 62910 60 0 0 {name=s339 lab=VDD}
N 63080 30 63080 10 {lab=VDD}
C {devices/vdd.sym} 63080 10 0 0 {name=s340 lab=VDD}
N 63080 60 63110 60 {lab=VDD}
C {devices/vdd.sym} 63110 60 0 0 {name=s341 lab=VDD}
N 63280 30 63280 10 {lab=VDD}
C {devices/vdd.sym} 63280 10 0 0 {name=s342 lab=VDD}
N 63280 60 63310 60 {lab=VDD}
C {devices/vdd.sym} 63310 60 0 0 {name=s343 lab=VDD}
N 63640 1400 63640 1420 {lab=0}
C {devices/gnd.sym} 63640 1420 0 0 {name=s344 lab=0}
N 63640 1370 63670 1370 {lab=0}
C {devices/gnd.sym} 63670 1370 0 0 {name=s345 lab=0}
N 63640 1220 63670 1220 {lab=0}
C {devices/gnd.sym} 63670 1220 0 0 {name=s346 lab=0}
N 63840 1220 63870 1220 {lab=0}
C {devices/gnd.sym} 63870 1220 0 0 {name=s347 lab=0}
N 63840 1400 63840 1420 {lab=0}
C {devices/gnd.sym} 63840 1420 0 0 {name=s348 lab=0}
N 63840 1370 63870 1370 {lab=0}
C {devices/gnd.sym} 63870 1370 0 0 {name=s349 lab=0}
N 63640 30 63640 10 {lab=VDD}
C {devices/vdd.sym} 63640 10 0 0 {name=s350 lab=VDD}
N 63640 60 63670 60 {lab=VDD}
C {devices/vdd.sym} 63670 60 0 0 {name=s351 lab=VDD}
N 63840 30 63840 10 {lab=VDD}
C {devices/vdd.sym} 63840 10 0 0 {name=s352 lab=VDD}
N 63840 60 63870 60 {lab=VDD}
C {devices/vdd.sym} 63870 60 0 0 {name=s353 lab=VDD}
N 63840 210 63870 210 {lab=VDD}
C {devices/vdd.sym} 63870 210 0 0 {name=s354 lab=VDD}
N 63640 210 63670 210 {lab=VDD}
C {devices/vdd.sym} 63670 210 0 0 {name=s355 lab=VDD}
N 64200 1400 64200 1420 {lab=0}
C {devices/gnd.sym} 64200 1420 0 0 {name=s356 lab=0}
N 64200 1370 64230 1370 {lab=0}
C {devices/gnd.sym} 64230 1370 0 0 {name=s357 lab=0}
N 64400 1400 64400 1420 {lab=0}
C {devices/gnd.sym} 64400 1420 0 0 {name=s358 lab=0}
N 64400 1370 64430 1370 {lab=0}
C {devices/gnd.sym} 64430 1370 0 0 {name=s359 lab=0}
N 64200 30 64200 10 {lab=VDD}
C {devices/vdd.sym} 64200 10 0 0 {name=s360 lab=VDD}
N 64200 60 64230 60 {lab=VDD}
C {devices/vdd.sym} 64230 60 0 0 {name=s361 lab=VDD}
N 64200 210 64230 210 {lab=VDD}
C {devices/vdd.sym} 64230 210 0 0 {name=s362 lab=VDD}
N 16000 1400 16000 1420 {lab=0}
C {devices/gnd.sym} 16000 1420 0 0 {name=s363 lab=0}
N 16000 1370 16030 1370 {lab=0}
C {devices/gnd.sym} 16030 1370 0 0 {name=s364 lab=0}
N 16200 1400 16200 1420 {lab=0}
C {devices/gnd.sym} 16200 1420 0 0 {name=s365 lab=0}
N 16200 1370 16230 1370 {lab=0}
C {devices/gnd.sym} 16230 1370 0 0 {name=s366 lab=0}
N 16400 1400 16400 1420 {lab=0}
C {devices/gnd.sym} 16400 1420 0 0 {name=s367 lab=0}
N 16400 1370 16430 1370 {lab=0}
C {devices/gnd.sym} 16430 1370 0 0 {name=s368 lab=0}
N 16000 30 16000 10 {lab=VDD}
C {devices/vdd.sym} 16000 10 0 0 {name=s369 lab=VDD}
N 16000 60 16030 60 {lab=VDD}
C {devices/vdd.sym} 16030 60 0 0 {name=s370 lab=VDD}
N 16000 210 16030 210 {lab=VDD}
C {devices/vdd.sym} 16030 210 0 0 {name=s371 lab=VDD}
N 16000 360 16030 360 {lab=VDD}
C {devices/vdd.sym} 16030 360 0 0 {name=s372 lab=VDD}
N 24040 1220 24070 1220 {lab=0}
C {devices/gnd.sym} 24070 1220 0 0 {name=s373 lab=0}
N 24240 1220 24270 1220 {lab=0}
C {devices/gnd.sym} 24270 1220 0 0 {name=s374 lab=0}
N 24040 1400 24040 1420 {lab=0}
C {devices/gnd.sym} 24040 1420 0 0 {name=s375 lab=0}
N 24040 1370 24070 1370 {lab=0}
C {devices/gnd.sym} 24070 1370 0 0 {name=s376 lab=0}
N 24040 30 24040 10 {lab=VDD}
C {devices/vdd.sym} 24040 10 0 0 {name=s377 lab=VDD}
N 24040 60 24070 60 {lab=VDD}
C {devices/vdd.sym} 24070 60 0 0 {name=s378 lab=VDD}
N 24040 210 24070 210 {lab=VDD}
C {devices/vdd.sym} 24070 210 0 0 {name=s379 lab=VDD}
N 24240 30 24240 10 {lab=VDD}
C {devices/vdd.sym} 24240 10 0 0 {name=s380 lab=VDD}
N 24240 60 24270 60 {lab=VDD}
C {devices/vdd.sym} 24270 60 0 0 {name=s381 lab=VDD}
N 67000 1400 67000 1420 {lab=0}
C {devices/gnd.sym} 67000 1420 0 0 {name=s382 lab=0}
N 67000 1370 67030 1370 {lab=0}
C {devices/gnd.sym} 67030 1370 0 0 {name=s383 lab=0}
N 67000 1220 67030 1220 {lab=0}
C {devices/gnd.sym} 67030 1220 0 0 {name=s384 lab=0}
N 67200 1400 67200 1420 {lab=0}
C {devices/gnd.sym} 67200 1420 0 0 {name=s385 lab=0}
N 67200 1370 67230 1370 {lab=0}
C {devices/gnd.sym} 67230 1370 0 0 {name=s386 lab=0}
N 67000 210 67030 210 {lab=VDD}
C {devices/vdd.sym} 67030 210 0 0 {name=s387 lab=VDD}
N 67200 210 67230 210 {lab=VDD}
C {devices/vdd.sym} 67230 210 0 0 {name=s388 lab=VDD}
N 67000 30 67000 10 {lab=VDD}
C {devices/vdd.sym} 67000 10 0 0 {name=s389 lab=VDD}
N 67000 60 67030 60 {lab=VDD}
C {devices/vdd.sym} 67030 60 0 0 {name=s390 lab=VDD}
N 67560 920 67590 920 {lab=0}
C {devices/gnd.sym} 67590 920 0 0 {name=s391 lab=0}
N 67560 1070 67590 1070 {lab=0}
C {devices/gnd.sym} 67590 1070 0 0 {name=s392 lab=0}
N 67560 1220 67590 1220 {lab=0}
C {devices/gnd.sym} 67590 1220 0 0 {name=s393 lab=0}
N 67560 1400 67560 1420 {lab=0}
C {devices/gnd.sym} 67560 1420 0 0 {name=s394 lab=0}
N 67560 1370 67590 1370 {lab=0}
C {devices/gnd.sym} 67590 1370 0 0 {name=s395 lab=0}
N 68520 1400 68520 1420 {lab=0}
C {devices/gnd.sym} 68520 1420 0 0 {name=s396 lab=0}
N 68520 1370 68550 1370 {lab=0}
C {devices/gnd.sym} 68550 1370 0 0 {name=s397 lab=0}
N 67560 30 67560 10 {lab=VDD}
C {devices/vdd.sym} 67560 10 0 0 {name=s398 lab=VDD}
N 67560 60 67590 60 {lab=VDD}
C {devices/vdd.sym} 67590 60 0 0 {name=s399 lab=VDD}
N 67760 30 67760 10 {lab=VDD}
C {devices/vdd.sym} 67760 10 0 0 {name=s400 lab=VDD}
N 67760 60 67790 60 {lab=VDD}
C {devices/vdd.sym} 67790 60 0 0 {name=s401 lab=VDD}
N 67960 30 67960 10 {lab=VDD}
C {devices/vdd.sym} 67960 10 0 0 {name=s402 lab=VDD}
N 67960 60 67990 60 {lab=VDD}
C {devices/vdd.sym} 67990 60 0 0 {name=s403 lab=VDD}
N 68160 30 68160 10 {lab=VDD}
C {devices/vdd.sym} 68160 10 0 0 {name=s404 lab=VDD}
N 68160 60 68190 60 {lab=VDD}
C {devices/vdd.sym} 68190 60 0 0 {name=s405 lab=VDD}
N 68520 30 68520 10 {lab=VDD}
C {devices/vdd.sym} 68520 10 0 0 {name=s406 lab=VDD}
N 68520 60 68550 60 {lab=VDD}
C {devices/vdd.sym} 68550 60 0 0 {name=s407 lab=VDD}
N 71120 1400 71120 1420 {lab=0}
C {devices/gnd.sym} 71120 1420 0 0 {name=s408 lab=0}
N 71120 1370 71150 1370 {lab=0}
C {devices/gnd.sym} 71150 1370 0 0 {name=s409 lab=0}
N 71320 1400 71320 1420 {lab=0}
C {devices/gnd.sym} 71320 1420 0 0 {name=s410 lab=0}
N 71320 1370 71350 1370 {lab=0}
C {devices/gnd.sym} 71350 1370 0 0 {name=s411 lab=0}
N 71120 30 71120 10 {lab=VDD}
C {devices/vdd.sym} 71120 10 0 0 {name=s412 lab=VDD}
N 71120 60 71150 60 {lab=VDD}
C {devices/vdd.sym} 71150 60 0 0 {name=s413 lab=VDD}
N 71120 210 71150 210 {lab=VDD}
C {devices/vdd.sym} 71150 210 0 0 {name=s414 lab=VDD}
N 71680 1400 71680 1420 {lab=0}
C {devices/gnd.sym} 71680 1420 0 0 {name=s415 lab=0}
N 71680 1370 71710 1370 {lab=0}
C {devices/gnd.sym} 71710 1370 0 0 {name=s416 lab=0}
N 71680 1220 71710 1220 {lab=0}
C {devices/gnd.sym} 71710 1220 0 0 {name=s417 lab=0}
N 71680 30 71680 10 {lab=VDD}
C {devices/vdd.sym} 71680 10 0 0 {name=s418 lab=VDD}
N 71680 60 71710 60 {lab=VDD}
C {devices/vdd.sym} 71710 60 0 0 {name=s419 lab=VDD}
N 71880 30 71880 10 {lab=VDD}
C {devices/vdd.sym} 71880 10 0 0 {name=s420 lab=VDD}
N 71880 60 71910 60 {lab=VDD}
C {devices/vdd.sym} 71910 60 0 0 {name=s421 lab=VDD}
N 72240 1400 72240 1420 {lab=0}
C {devices/gnd.sym} 72240 1420 0 0 {name=s422 lab=0}
N 72240 1370 72270 1370 {lab=0}
C {devices/gnd.sym} 72270 1370 0 0 {name=s423 lab=0}
N 72240 1220 72270 1220 {lab=0}
C {devices/gnd.sym} 72270 1220 0 0 {name=s424 lab=0}
N 72440 1220 72470 1220 {lab=0}
C {devices/gnd.sym} 72470 1220 0 0 {name=s425 lab=0}
N 72440 1400 72440 1420 {lab=0}
C {devices/gnd.sym} 72440 1420 0 0 {name=s426 lab=0}
N 72440 1370 72470 1370 {lab=0}
C {devices/gnd.sym} 72470 1370 0 0 {name=s427 lab=0}
N 72240 30 72240 10 {lab=VDD}
C {devices/vdd.sym} 72240 10 0 0 {name=s428 lab=VDD}
N 72240 60 72270 60 {lab=VDD}
C {devices/vdd.sym} 72270 60 0 0 {name=s429 lab=VDD}
N 72440 30 72440 10 {lab=VDD}
C {devices/vdd.sym} 72440 10 0 0 {name=s430 lab=VDD}
N 72440 60 72470 60 {lab=VDD}
C {devices/vdd.sym} 72470 60 0 0 {name=s431 lab=VDD}
N 72440 210 72470 210 {lab=VDD}
C {devices/vdd.sym} 72470 210 0 0 {name=s432 lab=VDD}
N 72240 210 72270 210 {lab=VDD}
C {devices/vdd.sym} 72270 210 0 0 {name=s433 lab=VDD}
N 72800 1400 72800 1420 {lab=0}
C {devices/gnd.sym} 72800 1420 0 0 {name=s434 lab=0}
N 72800 1370 72830 1370 {lab=0}
C {devices/gnd.sym} 72830 1370 0 0 {name=s435 lab=0}
N 73000 1400 73000 1420 {lab=0}
C {devices/gnd.sym} 73000 1420 0 0 {name=s436 lab=0}
N 73000 1370 73030 1370 {lab=0}
C {devices/gnd.sym} 73030 1370 0 0 {name=s437 lab=0}
N 72800 30 72800 10 {lab=VDD}
C {devices/vdd.sym} 72800 10 0 0 {name=s438 lab=VDD}
N 72800 60 72830 60 {lab=VDD}
C {devices/vdd.sym} 72830 60 0 0 {name=s439 lab=VDD}
N 72800 210 72830 210 {lab=VDD}
C {devices/vdd.sym} 72830 210 0 0 {name=s440 lab=VDD}
N 16760 1400 16760 1420 {lab=0}
C {devices/gnd.sym} 16760 1420 0 0 {name=s441 lab=0}
N 16760 1370 16790 1370 {lab=0}
C {devices/gnd.sym} 16790 1370 0 0 {name=s442 lab=0}
N 16960 1400 16960 1420 {lab=0}
C {devices/gnd.sym} 16960 1420 0 0 {name=s443 lab=0}
N 16960 1370 16990 1370 {lab=0}
C {devices/gnd.sym} 16990 1370 0 0 {name=s444 lab=0}
N 17160 1400 17160 1420 {lab=0}
C {devices/gnd.sym} 17160 1420 0 0 {name=s445 lab=0}
N 17160 1370 17190 1370 {lab=0}
C {devices/gnd.sym} 17190 1370 0 0 {name=s446 lab=0}
N 16760 30 16760 10 {lab=VDD}
C {devices/vdd.sym} 16760 10 0 0 {name=s447 lab=VDD}
N 16760 60 16790 60 {lab=VDD}
C {devices/vdd.sym} 16790 60 0 0 {name=s448 lab=VDD}
N 16760 210 16790 210 {lab=VDD}
C {devices/vdd.sym} 16790 210 0 0 {name=s449 lab=VDD}
N 16760 360 16790 360 {lab=VDD}
C {devices/vdd.sym} 16790 360 0 0 {name=s450 lab=VDD}
N 24600 1220 24630 1220 {lab=0}
C {devices/gnd.sym} 24630 1220 0 0 {name=s451 lab=0}
N 24800 1220 24830 1220 {lab=0}
C {devices/gnd.sym} 24830 1220 0 0 {name=s452 lab=0}
N 24600 1400 24600 1420 {lab=0}
C {devices/gnd.sym} 24600 1420 0 0 {name=s453 lab=0}
N 24600 1370 24630 1370 {lab=0}
C {devices/gnd.sym} 24630 1370 0 0 {name=s454 lab=0}
N 24600 30 24600 10 {lab=VDD}
C {devices/vdd.sym} 24600 10 0 0 {name=s455 lab=VDD}
N 24600 60 24630 60 {lab=VDD}
C {devices/vdd.sym} 24630 60 0 0 {name=s456 lab=VDD}
N 24600 210 24630 210 {lab=VDD}
C {devices/vdd.sym} 24630 210 0 0 {name=s457 lab=VDD}
N 24800 30 24800 10 {lab=VDD}
C {devices/vdd.sym} 24800 10 0 0 {name=s458 lab=VDD}
N 24800 60 24830 60 {lab=VDD}
C {devices/vdd.sym} 24830 60 0 0 {name=s459 lab=VDD}
N 75600 1400 75600 1420 {lab=0}
C {devices/gnd.sym} 75600 1420 0 0 {name=s460 lab=0}
N 75600 1370 75630 1370 {lab=0}
C {devices/gnd.sym} 75630 1370 0 0 {name=s461 lab=0}
N 75600 1220 75630 1220 {lab=0}
C {devices/gnd.sym} 75630 1220 0 0 {name=s462 lab=0}
N 75800 1400 75800 1420 {lab=0}
C {devices/gnd.sym} 75800 1420 0 0 {name=s463 lab=0}
N 75800 1370 75830 1370 {lab=0}
C {devices/gnd.sym} 75830 1370 0 0 {name=s464 lab=0}
N 75600 210 75630 210 {lab=VDD}
C {devices/vdd.sym} 75630 210 0 0 {name=s465 lab=VDD}
N 75800 210 75830 210 {lab=VDD}
C {devices/vdd.sym} 75830 210 0 0 {name=s466 lab=VDD}
N 75600 30 75600 10 {lab=VDD}
C {devices/vdd.sym} 75600 10 0 0 {name=s467 lab=VDD}
N 75600 60 75630 60 {lab=VDD}
C {devices/vdd.sym} 75630 60 0 0 {name=s468 lab=VDD}
N 76160 1070 76190 1070 {lab=0}
C {devices/gnd.sym} 76190 1070 0 0 {name=s469 lab=0}
N 76160 1220 76190 1220 {lab=0}
C {devices/gnd.sym} 76190 1220 0 0 {name=s470 lab=0}
N 76160 1400 76160 1420 {lab=0}
C {devices/gnd.sym} 76160 1420 0 0 {name=s471 lab=0}
N 76160 1370 76190 1370 {lab=0}
C {devices/gnd.sym} 76190 1370 0 0 {name=s472 lab=0}
N 76920 1400 76920 1420 {lab=0}
C {devices/gnd.sym} 76920 1420 0 0 {name=s473 lab=0}
N 76920 1370 76950 1370 {lab=0}
C {devices/gnd.sym} 76950 1370 0 0 {name=s474 lab=0}
N 76160 30 76160 10 {lab=VDD}
C {devices/vdd.sym} 76160 10 0 0 {name=s475 lab=VDD}
N 76160 60 76190 60 {lab=VDD}
C {devices/vdd.sym} 76190 60 0 0 {name=s476 lab=VDD}
N 76360 30 76360 10 {lab=VDD}
C {devices/vdd.sym} 76360 10 0 0 {name=s477 lab=VDD}
N 76360 60 76390 60 {lab=VDD}
C {devices/vdd.sym} 76390 60 0 0 {name=s478 lab=VDD}
N 76560 30 76560 10 {lab=VDD}
C {devices/vdd.sym} 76560 10 0 0 {name=s479 lab=VDD}
N 76560 60 76590 60 {lab=VDD}
C {devices/vdd.sym} 76590 60 0 0 {name=s480 lab=VDD}
N 76920 30 76920 10 {lab=VDD}
C {devices/vdd.sym} 76920 10 0 0 {name=s481 lab=VDD}
N 76920 60 76950 60 {lab=VDD}
C {devices/vdd.sym} 76950 60 0 0 {name=s482 lab=VDD}
N 80280 1400 80280 1420 {lab=0}
C {devices/gnd.sym} 80280 1420 0 0 {name=s483 lab=0}
N 80280 1370 80310 1370 {lab=0}
C {devices/gnd.sym} 80310 1370 0 0 {name=s484 lab=0}
N 80480 1400 80480 1420 {lab=0}
C {devices/gnd.sym} 80480 1420 0 0 {name=s485 lab=0}
N 80480 1370 80510 1370 {lab=0}
C {devices/gnd.sym} 80510 1370 0 0 {name=s486 lab=0}
N 80280 30 80280 10 {lab=VDD}
C {devices/vdd.sym} 80280 10 0 0 {name=s487 lab=VDD}
N 80280 60 80310 60 {lab=VDD}
C {devices/vdd.sym} 80310 60 0 0 {name=s488 lab=VDD}
N 80280 210 80310 210 {lab=VDD}
C {devices/vdd.sym} 80310 210 0 0 {name=s489 lab=VDD}
N 80840 1400 80840 1420 {lab=0}
C {devices/gnd.sym} 80840 1420 0 0 {name=s490 lab=0}
N 80840 1370 80870 1370 {lab=0}
C {devices/gnd.sym} 80870 1370 0 0 {name=s491 lab=0}
N 80840 1220 80870 1220 {lab=0}
C {devices/gnd.sym} 80870 1220 0 0 {name=s492 lab=0}
N 80840 30 80840 10 {lab=VDD}
C {devices/vdd.sym} 80840 10 0 0 {name=s493 lab=VDD}
N 80840 60 80870 60 {lab=VDD}
C {devices/vdd.sym} 80870 60 0 0 {name=s494 lab=VDD}
N 81040 30 81040 10 {lab=VDD}
C {devices/vdd.sym} 81040 10 0 0 {name=s495 lab=VDD}
N 81040 60 81070 60 {lab=VDD}
C {devices/vdd.sym} 81070 60 0 0 {name=s496 lab=VDD}
N 81400 1400 81400 1420 {lab=0}
C {devices/gnd.sym} 81400 1420 0 0 {name=s497 lab=0}
N 81400 1370 81430 1370 {lab=0}
C {devices/gnd.sym} 81430 1370 0 0 {name=s498 lab=0}
N 81400 1220 81430 1220 {lab=0}
C {devices/gnd.sym} 81430 1220 0 0 {name=s499 lab=0}
N 81600 1220 81630 1220 {lab=0}
C {devices/gnd.sym} 81630 1220 0 0 {name=s500 lab=0}
N 81600 1400 81600 1420 {lab=0}
C {devices/gnd.sym} 81600 1420 0 0 {name=s501 lab=0}
N 81600 1370 81630 1370 {lab=0}
C {devices/gnd.sym} 81630 1370 0 0 {name=s502 lab=0}
N 81400 30 81400 10 {lab=VDD}
C {devices/vdd.sym} 81400 10 0 0 {name=s503 lab=VDD}
N 81400 60 81430 60 {lab=VDD}
C {devices/vdd.sym} 81430 60 0 0 {name=s504 lab=VDD}
N 81600 30 81600 10 {lab=VDD}
C {devices/vdd.sym} 81600 10 0 0 {name=s505 lab=VDD}
N 81600 60 81630 60 {lab=VDD}
C {devices/vdd.sym} 81630 60 0 0 {name=s506 lab=VDD}
N 81600 210 81630 210 {lab=VDD}
C {devices/vdd.sym} 81630 210 0 0 {name=s507 lab=VDD}
N 81400 210 81430 210 {lab=VDD}
C {devices/vdd.sym} 81430 210 0 0 {name=s508 lab=VDD}
N 81960 1400 81960 1420 {lab=0}
C {devices/gnd.sym} 81960 1420 0 0 {name=s509 lab=0}
N 81960 1370 81990 1370 {lab=0}
C {devices/gnd.sym} 81990 1370 0 0 {name=s510 lab=0}
N 82160 1400 82160 1420 {lab=0}
C {devices/gnd.sym} 82160 1420 0 0 {name=s511 lab=0}
N 82160 1370 82190 1370 {lab=0}
C {devices/gnd.sym} 82190 1370 0 0 {name=s512 lab=0}
N 81960 30 81960 10 {lab=VDD}
C {devices/vdd.sym} 81960 10 0 0 {name=s513 lab=VDD}
N 81960 60 81990 60 {lab=VDD}
C {devices/vdd.sym} 81990 60 0 0 {name=s514 lab=VDD}
N 81960 210 81990 210 {lab=VDD}
C {devices/vdd.sym} 81990 210 0 0 {name=s515 lab=VDD}
N 77280 1400 77280 1420 {lab=0}
C {devices/gnd.sym} 77280 1420 0 0 {name=s516 lab=0}
N 77280 1370 77310 1370 {lab=0}
C {devices/gnd.sym} 77310 1370 0 0 {name=s517 lab=0}
N 77280 1220 77310 1220 {lab=0}
C {devices/gnd.sym} 77310 1220 0 0 {name=s518 lab=0}
N 77280 1070 77310 1070 {lab=0}
C {devices/gnd.sym} 77310 1070 0 0 {name=s519 lab=0}
N 77280 30 77280 10 {lab=VDD}
C {devices/vdd.sym} 77280 10 0 0 {name=s520 lab=VDD}
N 77280 60 77310 60 {lab=VDD}
C {devices/vdd.sym} 77310 60 0 0 {name=s521 lab=VDD}
N 77480 30 77480 10 {lab=VDD}
C {devices/vdd.sym} 77480 10 0 0 {name=s522 lab=VDD}
N 77480 60 77510 60 {lab=VDD}
C {devices/vdd.sym} 77510 60 0 0 {name=s523 lab=VDD}
N 77680 30 77680 10 {lab=VDD}
C {devices/vdd.sym} 77680 10 0 0 {name=s524 lab=VDD}
N 77680 60 77710 60 {lab=VDD}
C {devices/vdd.sym} 77710 60 0 0 {name=s525 lab=VDD}
N 17520 1220 17550 1220 {lab=0}
C {devices/gnd.sym} 17550 1220 0 0 {name=s526 lab=0}
N 17720 1220 17750 1220 {lab=0}
C {devices/gnd.sym} 17750 1220 0 0 {name=s527 lab=0}
N 17520 1400 17520 1420 {lab=0}
C {devices/gnd.sym} 17520 1420 0 0 {name=s528 lab=0}
N 17520 1370 17550 1370 {lab=0}
C {devices/gnd.sym} 17550 1370 0 0 {name=s529 lab=0}
N 17520 30 17520 10 {lab=VDD}
C {devices/vdd.sym} 17520 10 0 0 {name=s530 lab=VDD}
N 17520 60 17550 60 {lab=VDD}
C {devices/vdd.sym} 17550 60 0 0 {name=s531 lab=VDD}
N 17520 210 17550 210 {lab=VDD}
C {devices/vdd.sym} 17550 210 0 0 {name=s532 lab=VDD}
N 17720 30 17720 10 {lab=VDD}
C {devices/vdd.sym} 17720 10 0 0 {name=s533 lab=VDD}
N 17720 60 17750 60 {lab=VDD}
C {devices/vdd.sym} 17750 60 0 0 {name=s534 lab=VDD}
N 25160 1400 25160 1420 {lab=0}
C {devices/gnd.sym} 25160 1420 0 0 {name=s535 lab=0}
N 25160 1370 25190 1370 {lab=0}
C {devices/gnd.sym} 25190 1370 0 0 {name=s536 lab=0}
N 25160 1220 25190 1220 {lab=0}
C {devices/gnd.sym} 25190 1220 0 0 {name=s537 lab=0}
N 25360 1400 25360 1420 {lab=0}
C {devices/gnd.sym} 25360 1420 0 0 {name=s538 lab=0}
N 25360 1370 25390 1370 {lab=0}
C {devices/gnd.sym} 25390 1370 0 0 {name=s539 lab=0}
N 25160 210 25190 210 {lab=VDD}
C {devices/vdd.sym} 25190 210 0 0 {name=s540 lab=VDD}
N 25360 210 25390 210 {lab=VDD}
C {devices/vdd.sym} 25390 210 0 0 {name=s541 lab=VDD}
N 25160 30 25160 10 {lab=VDD}
C {devices/vdd.sym} 25160 10 0 0 {name=s542 lab=VDD}
N 25160 60 25190 60 {lab=VDD}
C {devices/vdd.sym} 25190 60 0 0 {name=s543 lab=VDD}
N 720 1400 720 1420 {lab=0}
C {devices/gnd.sym} 720 1420 0 0 {name=s544 lab=0}
N 720 1370 750 1370 {lab=0}
C {devices/gnd.sym} 750 1370 0 0 {name=s545 lab=0}
N 6840 1400 6840 1420 {lab=0}
C {devices/gnd.sym} 6840 1420 0 0 {name=s546 lab=0}
N 6840 1370 6870 1370 {lab=0}
C {devices/gnd.sym} 6870 1370 0 0 {name=s547 lab=0}
N 25720 1400 25720 1420 {lab=0}
C {devices/gnd.sym} 25720 1420 0 0 {name=s548 lab=0}
N 25720 1370 25750 1370 {lab=0}
C {devices/gnd.sym} 25750 1370 0 0 {name=s549 lab=0}
N 25720 1220 25750 1220 {lab=0}
C {devices/gnd.sym} 25750 1220 0 0 {name=s550 lab=0}
N 25920 1070 25950 1070 {lab=0}
C {devices/gnd.sym} 25950 1070 0 0 {name=s551 lab=0}
N 25920 1220 25950 1220 {lab=0}
C {devices/gnd.sym} 25950 1220 0 0 {name=s552 lab=0}
N 25920 1400 25920 1420 {lab=0}
C {devices/gnd.sym} 25920 1420 0 0 {name=s553 lab=0}
N 25920 1370 25950 1370 {lab=0}
C {devices/gnd.sym} 25950 1370 0 0 {name=s554 lab=0}
N 27040 1400 27040 1420 {lab=0}
C {devices/gnd.sym} 27040 1420 0 0 {name=s555 lab=0}
N 27040 1370 27070 1370 {lab=0}
C {devices/gnd.sym} 27070 1370 0 0 {name=s556 lab=0}
N 27040 1220 27070 1220 {lab=0}
C {devices/gnd.sym} 27070 1220 0 0 {name=s557 lab=0}
N 27240 1220 27270 1220 {lab=0}
C {devices/gnd.sym} 27270 1220 0 0 {name=s558 lab=0}
N 27240 1400 27240 1420 {lab=0}
C {devices/gnd.sym} 27240 1420 0 0 {name=s559 lab=0}
N 27240 1370 27270 1370 {lab=0}
C {devices/gnd.sym} 27270 1370 0 0 {name=s560 lab=0}
N 26480 1400 26480 1420 {lab=0}
C {devices/gnd.sym} 26480 1420 0 0 {name=s561 lab=0}
N 26480 1370 26510 1370 {lab=0}
C {devices/gnd.sym} 26510 1370 0 0 {name=s562 lab=0}
N 26480 1220 26510 1220 {lab=0}
C {devices/gnd.sym} 26510 1220 0 0 {name=s563 lab=0}
N 27600 1400 27600 1420 {lab=0}
C {devices/gnd.sym} 27600 1420 0 0 {name=s564 lab=0}
N 27600 1370 27630 1370 {lab=0}
C {devices/gnd.sym} 27630 1370 0 0 {name=s565 lab=0}
N 720 30 720 10 {lab=VDD}
C {devices/vdd.sym} 720 10 0 0 {name=s566 lab=VDD}
N 720 60 750 60 {lab=VDD}
C {devices/vdd.sym} 750 60 0 0 {name=s567 lab=VDD}
N 6840 30 6840 10 {lab=VDD}
C {devices/vdd.sym} 6840 10 0 0 {name=s568 lab=VDD}
N 6840 60 6870 60 {lab=VDD}
C {devices/vdd.sym} 6870 60 0 0 {name=s569 lab=VDD}
N 25720 30 25720 10 {lab=VDD}
C {devices/vdd.sym} 25720 10 0 0 {name=s570 lab=VDD}
N 25720 60 25750 60 {lab=VDD}
C {devices/vdd.sym} 25750 60 0 0 {name=s571 lab=VDD}
N 25720 210 25750 210 {lab=VDD}
C {devices/vdd.sym} 25750 210 0 0 {name=s572 lab=VDD}
N 26120 210 26150 210 {lab=VDD}
C {devices/vdd.sym} 26150 210 0 0 {name=s573 lab=VDD}
N 25920 30 25920 10 {lab=VDD}
C {devices/vdd.sym} 25920 10 0 0 {name=s574 lab=VDD}
N 25920 60 25950 60 {lab=VDD}
C {devices/vdd.sym} 25950 60 0 0 {name=s575 lab=VDD}
N 26120 30 26120 10 {lab=VDD}
C {devices/vdd.sym} 26120 10 0 0 {name=s576 lab=VDD}
N 26120 60 26150 60 {lab=VDD}
C {devices/vdd.sym} 26150 60 0 0 {name=s577 lab=VDD}
N 27040 30 27040 10 {lab=VDD}
C {devices/vdd.sym} 27040 10 0 0 {name=s578 lab=VDD}
N 27040 60 27070 60 {lab=VDD}
C {devices/vdd.sym} 27070 60 0 0 {name=s579 lab=VDD}
N 27040 210 27070 210 {lab=VDD}
C {devices/vdd.sym} 27070 210 0 0 {name=s580 lab=VDD}
N 27240 210 27270 210 {lab=VDD}
C {devices/vdd.sym} 27270 210 0 0 {name=s581 lab=VDD}
N 27240 30 27240 10 {lab=VDD}
C {devices/vdd.sym} 27240 10 0 0 {name=s582 lab=VDD}
N 27240 60 27270 60 {lab=VDD}
C {devices/vdd.sym} 27270 60 0 0 {name=s583 lab=VDD}
N 26480 30 26480 10 {lab=VDD}
C {devices/vdd.sym} 26480 10 0 0 {name=s584 lab=VDD}
N 26480 60 26510 60 {lab=VDD}
C {devices/vdd.sym} 26510 60 0 0 {name=s585 lab=VDD}
N 26680 30 26680 10 {lab=VDD}
C {devices/vdd.sym} 26680 10 0 0 {name=s586 lab=VDD}
N 26680 60 26710 60 {lab=VDD}
C {devices/vdd.sym} 26710 60 0 0 {name=s587 lab=VDD}
N 27600 30 27600 10 {lab=VDD}
C {devices/vdd.sym} 27600 10 0 0 {name=s588 lab=VDD}
N 27600 60 27630 60 {lab=VDD}
C {devices/vdd.sym} 27630 60 0 0 {name=s589 lab=VDD}
N 1080 1400 1080 1420 {lab=0}
C {devices/gnd.sym} 1080 1420 0 0 {name=s590 lab=0}
N 1080 1370 1110 1370 {lab=0}
C {devices/gnd.sym} 1110 1370 0 0 {name=s591 lab=0}
N 7200 1400 7200 1420 {lab=0}
C {devices/gnd.sym} 7200 1420 0 0 {name=s592 lab=0}
N 7200 1370 7230 1370 {lab=0}
C {devices/gnd.sym} 7230 1370 0 0 {name=s593 lab=0}
N 28920 1400 28920 1420 {lab=0}
C {devices/gnd.sym} 28920 1420 0 0 {name=s594 lab=0}
N 28920 1370 28950 1370 {lab=0}
C {devices/gnd.sym} 28950 1370 0 0 {name=s595 lab=0}
N 28920 1220 28950 1220 {lab=0}
C {devices/gnd.sym} 28950 1220 0 0 {name=s596 lab=0}
N 29120 1070 29150 1070 {lab=0}
C {devices/gnd.sym} 29150 1070 0 0 {name=s597 lab=0}
N 29120 1220 29150 1220 {lab=0}
C {devices/gnd.sym} 29150 1220 0 0 {name=s598 lab=0}
N 29120 1400 29120 1420 {lab=0}
C {devices/gnd.sym} 29120 1420 0 0 {name=s599 lab=0}
N 29120 1370 29150 1370 {lab=0}
C {devices/gnd.sym} 29150 1370 0 0 {name=s600 lab=0}
N 30240 1400 30240 1420 {lab=0}
C {devices/gnd.sym} 30240 1420 0 0 {name=s601 lab=0}
N 30240 1370 30270 1370 {lab=0}
C {devices/gnd.sym} 30270 1370 0 0 {name=s602 lab=0}
N 30240 1220 30270 1220 {lab=0}
C {devices/gnd.sym} 30270 1220 0 0 {name=s603 lab=0}
N 30440 1220 30470 1220 {lab=0}
C {devices/gnd.sym} 30470 1220 0 0 {name=s604 lab=0}
N 30440 1400 30440 1420 {lab=0}
C {devices/gnd.sym} 30440 1420 0 0 {name=s605 lab=0}
N 30440 1370 30470 1370 {lab=0}
C {devices/gnd.sym} 30470 1370 0 0 {name=s606 lab=0}
N 29680 1400 29680 1420 {lab=0}
C {devices/gnd.sym} 29680 1420 0 0 {name=s607 lab=0}
N 29680 1370 29710 1370 {lab=0}
C {devices/gnd.sym} 29710 1370 0 0 {name=s608 lab=0}
N 29680 1220 29710 1220 {lab=0}
C {devices/gnd.sym} 29710 1220 0 0 {name=s609 lab=0}
N 30800 1400 30800 1420 {lab=0}
C {devices/gnd.sym} 30800 1420 0 0 {name=s610 lab=0}
N 30800 1370 30830 1370 {lab=0}
C {devices/gnd.sym} 30830 1370 0 0 {name=s611 lab=0}
N 1080 30 1080 10 {lab=VDD}
C {devices/vdd.sym} 1080 10 0 0 {name=s612 lab=VDD}
N 1080 60 1110 60 {lab=VDD}
C {devices/vdd.sym} 1110 60 0 0 {name=s613 lab=VDD}
N 7200 30 7200 10 {lab=VDD}
C {devices/vdd.sym} 7200 10 0 0 {name=s614 lab=VDD}
N 7200 60 7230 60 {lab=VDD}
C {devices/vdd.sym} 7230 60 0 0 {name=s615 lab=VDD}
N 28920 30 28920 10 {lab=VDD}
C {devices/vdd.sym} 28920 10 0 0 {name=s616 lab=VDD}
N 28920 60 28950 60 {lab=VDD}
C {devices/vdd.sym} 28950 60 0 0 {name=s617 lab=VDD}
N 28920 210 28950 210 {lab=VDD}
C {devices/vdd.sym} 28950 210 0 0 {name=s618 lab=VDD}
N 29320 210 29350 210 {lab=VDD}
C {devices/vdd.sym} 29350 210 0 0 {name=s619 lab=VDD}
N 29120 30 29120 10 {lab=VDD}
C {devices/vdd.sym} 29120 10 0 0 {name=s620 lab=VDD}
N 29120 60 29150 60 {lab=VDD}
C {devices/vdd.sym} 29150 60 0 0 {name=s621 lab=VDD}
N 29320 30 29320 10 {lab=VDD}
C {devices/vdd.sym} 29320 10 0 0 {name=s622 lab=VDD}
N 29320 60 29350 60 {lab=VDD}
C {devices/vdd.sym} 29350 60 0 0 {name=s623 lab=VDD}
N 30240 30 30240 10 {lab=VDD}
C {devices/vdd.sym} 30240 10 0 0 {name=s624 lab=VDD}
N 30240 60 30270 60 {lab=VDD}
C {devices/vdd.sym} 30270 60 0 0 {name=s625 lab=VDD}
N 30240 210 30270 210 {lab=VDD}
C {devices/vdd.sym} 30270 210 0 0 {name=s626 lab=VDD}
N 30440 210 30470 210 {lab=VDD}
C {devices/vdd.sym} 30470 210 0 0 {name=s627 lab=VDD}
N 30440 30 30440 10 {lab=VDD}
C {devices/vdd.sym} 30440 10 0 0 {name=s628 lab=VDD}
N 30440 60 30470 60 {lab=VDD}
C {devices/vdd.sym} 30470 60 0 0 {name=s629 lab=VDD}
N 29680 30 29680 10 {lab=VDD}
C {devices/vdd.sym} 29680 10 0 0 {name=s630 lab=VDD}
N 29680 60 29710 60 {lab=VDD}
C {devices/vdd.sym} 29710 60 0 0 {name=s631 lab=VDD}
N 29880 30 29880 10 {lab=VDD}
C {devices/vdd.sym} 29880 10 0 0 {name=s632 lab=VDD}
N 29880 60 29910 60 {lab=VDD}
C {devices/vdd.sym} 29910 60 0 0 {name=s633 lab=VDD}
N 30800 30 30800 10 {lab=VDD}
C {devices/vdd.sym} 30800 10 0 0 {name=s634 lab=VDD}
N 30800 60 30830 60 {lab=VDD}
C {devices/vdd.sym} 30830 60 0 0 {name=s635 lab=VDD}
N 1440 1400 1440 1420 {lab=0}
C {devices/gnd.sym} 1440 1420 0 0 {name=s636 lab=0}
N 1440 1370 1470 1370 {lab=0}
C {devices/gnd.sym} 1470 1370 0 0 {name=s637 lab=0}
N 7560 1400 7560 1420 {lab=0}
C {devices/gnd.sym} 7560 1420 0 0 {name=s638 lab=0}
N 7560 1370 7590 1370 {lab=0}
C {devices/gnd.sym} 7590 1370 0 0 {name=s639 lab=0}
N 34160 1400 34160 1420 {lab=0}
C {devices/gnd.sym} 34160 1420 0 0 {name=s640 lab=0}
N 34160 1370 34190 1370 {lab=0}
C {devices/gnd.sym} 34190 1370 0 0 {name=s641 lab=0}
N 34160 1220 34190 1220 {lab=0}
C {devices/gnd.sym} 34190 1220 0 0 {name=s642 lab=0}
N 34360 1070 34390 1070 {lab=0}
C {devices/gnd.sym} 34390 1070 0 0 {name=s643 lab=0}
N 34360 1220 34390 1220 {lab=0}
C {devices/gnd.sym} 34390 1220 0 0 {name=s644 lab=0}
N 34360 1400 34360 1420 {lab=0}
C {devices/gnd.sym} 34360 1420 0 0 {name=s645 lab=0}
N 34360 1370 34390 1370 {lab=0}
C {devices/gnd.sym} 34390 1370 0 0 {name=s646 lab=0}
N 35480 1400 35480 1420 {lab=0}
C {devices/gnd.sym} 35480 1420 0 0 {name=s647 lab=0}
N 35480 1370 35510 1370 {lab=0}
C {devices/gnd.sym} 35510 1370 0 0 {name=s648 lab=0}
N 35480 1220 35510 1220 {lab=0}
C {devices/gnd.sym} 35510 1220 0 0 {name=s649 lab=0}
N 35680 1220 35710 1220 {lab=0}
C {devices/gnd.sym} 35710 1220 0 0 {name=s650 lab=0}
N 35680 1400 35680 1420 {lab=0}
C {devices/gnd.sym} 35680 1420 0 0 {name=s651 lab=0}
N 35680 1370 35710 1370 {lab=0}
C {devices/gnd.sym} 35710 1370 0 0 {name=s652 lab=0}
N 34920 1400 34920 1420 {lab=0}
C {devices/gnd.sym} 34920 1420 0 0 {name=s653 lab=0}
N 34920 1370 34950 1370 {lab=0}
C {devices/gnd.sym} 34950 1370 0 0 {name=s654 lab=0}
N 34920 1220 34950 1220 {lab=0}
C {devices/gnd.sym} 34950 1220 0 0 {name=s655 lab=0}
N 36040 1400 36040 1420 {lab=0}
C {devices/gnd.sym} 36040 1420 0 0 {name=s656 lab=0}
N 36040 1370 36070 1370 {lab=0}
C {devices/gnd.sym} 36070 1370 0 0 {name=s657 lab=0}
N 1440 30 1440 10 {lab=VDD}
C {devices/vdd.sym} 1440 10 0 0 {name=s658 lab=VDD}
N 1440 60 1470 60 {lab=VDD}
C {devices/vdd.sym} 1470 60 0 0 {name=s659 lab=VDD}
N 7560 30 7560 10 {lab=VDD}
C {devices/vdd.sym} 7560 10 0 0 {name=s660 lab=VDD}
N 7560 60 7590 60 {lab=VDD}
C {devices/vdd.sym} 7590 60 0 0 {name=s661 lab=VDD}
N 34160 30 34160 10 {lab=VDD}
C {devices/vdd.sym} 34160 10 0 0 {name=s662 lab=VDD}
N 34160 60 34190 60 {lab=VDD}
C {devices/vdd.sym} 34190 60 0 0 {name=s663 lab=VDD}
N 34160 210 34190 210 {lab=VDD}
C {devices/vdd.sym} 34190 210 0 0 {name=s664 lab=VDD}
N 34560 210 34590 210 {lab=VDD}
C {devices/vdd.sym} 34590 210 0 0 {name=s665 lab=VDD}
N 34360 30 34360 10 {lab=VDD}
C {devices/vdd.sym} 34360 10 0 0 {name=s666 lab=VDD}
N 34360 60 34390 60 {lab=VDD}
C {devices/vdd.sym} 34390 60 0 0 {name=s667 lab=VDD}
N 34560 30 34560 10 {lab=VDD}
C {devices/vdd.sym} 34560 10 0 0 {name=s668 lab=VDD}
N 34560 60 34590 60 {lab=VDD}
C {devices/vdd.sym} 34590 60 0 0 {name=s669 lab=VDD}
N 35480 30 35480 10 {lab=VDD}
C {devices/vdd.sym} 35480 10 0 0 {name=s670 lab=VDD}
N 35480 60 35510 60 {lab=VDD}
C {devices/vdd.sym} 35510 60 0 0 {name=s671 lab=VDD}
N 35480 210 35510 210 {lab=VDD}
C {devices/vdd.sym} 35510 210 0 0 {name=s672 lab=VDD}
N 35680 210 35710 210 {lab=VDD}
C {devices/vdd.sym} 35710 210 0 0 {name=s673 lab=VDD}
N 35680 30 35680 10 {lab=VDD}
C {devices/vdd.sym} 35680 10 0 0 {name=s674 lab=VDD}
N 35680 60 35710 60 {lab=VDD}
C {devices/vdd.sym} 35710 60 0 0 {name=s675 lab=VDD}
N 34920 30 34920 10 {lab=VDD}
C {devices/vdd.sym} 34920 10 0 0 {name=s676 lab=VDD}
N 34920 60 34950 60 {lab=VDD}
C {devices/vdd.sym} 34950 60 0 0 {name=s677 lab=VDD}
N 35120 30 35120 10 {lab=VDD}
C {devices/vdd.sym} 35120 10 0 0 {name=s678 lab=VDD}
N 35120 60 35150 60 {lab=VDD}
C {devices/vdd.sym} 35150 60 0 0 {name=s679 lab=VDD}
N 36040 30 36040 10 {lab=VDD}
C {devices/vdd.sym} 36040 10 0 0 {name=s680 lab=VDD}
N 36040 60 36070 60 {lab=VDD}
C {devices/vdd.sym} 36070 60 0 0 {name=s681 lab=VDD}
N 1800 1400 1800 1420 {lab=0}
C {devices/gnd.sym} 1800 1420 0 0 {name=s682 lab=0}
N 1800 1370 1830 1370 {lab=0}
C {devices/gnd.sym} 1830 1370 0 0 {name=s683 lab=0}
N 7920 1400 7920 1420 {lab=0}
C {devices/gnd.sym} 7920 1420 0 0 {name=s684 lab=0}
N 7920 1370 7950 1370 {lab=0}
C {devices/gnd.sym} 7950 1370 0 0 {name=s685 lab=0}
N 36760 1400 36760 1420 {lab=0}
C {devices/gnd.sym} 36760 1420 0 0 {name=s686 lab=0}
N 36760 1370 36790 1370 {lab=0}
C {devices/gnd.sym} 36790 1370 0 0 {name=s687 lab=0}
N 36760 1220 36790 1220 {lab=0}
C {devices/gnd.sym} 36790 1220 0 0 {name=s688 lab=0}
N 36960 1070 36990 1070 {lab=0}
C {devices/gnd.sym} 36990 1070 0 0 {name=s689 lab=0}
N 36960 1220 36990 1220 {lab=0}
C {devices/gnd.sym} 36990 1220 0 0 {name=s690 lab=0}
N 36960 1400 36960 1420 {lab=0}
C {devices/gnd.sym} 36960 1420 0 0 {name=s691 lab=0}
N 36960 1370 36990 1370 {lab=0}
C {devices/gnd.sym} 36990 1370 0 0 {name=s692 lab=0}
N 38080 1400 38080 1420 {lab=0}
C {devices/gnd.sym} 38080 1420 0 0 {name=s693 lab=0}
N 38080 1370 38110 1370 {lab=0}
C {devices/gnd.sym} 38110 1370 0 0 {name=s694 lab=0}
N 38080 1220 38110 1220 {lab=0}
C {devices/gnd.sym} 38110 1220 0 0 {name=s695 lab=0}
N 38280 1220 38310 1220 {lab=0}
C {devices/gnd.sym} 38310 1220 0 0 {name=s696 lab=0}
N 38280 1400 38280 1420 {lab=0}
C {devices/gnd.sym} 38280 1420 0 0 {name=s697 lab=0}
N 38280 1370 38310 1370 {lab=0}
C {devices/gnd.sym} 38310 1370 0 0 {name=s698 lab=0}
N 37520 1400 37520 1420 {lab=0}
C {devices/gnd.sym} 37520 1420 0 0 {name=s699 lab=0}
N 37520 1370 37550 1370 {lab=0}
C {devices/gnd.sym} 37550 1370 0 0 {name=s700 lab=0}
N 37520 1220 37550 1220 {lab=0}
C {devices/gnd.sym} 37550 1220 0 0 {name=s701 lab=0}
N 38640 1400 38640 1420 {lab=0}
C {devices/gnd.sym} 38640 1420 0 0 {name=s702 lab=0}
N 38640 1370 38670 1370 {lab=0}
C {devices/gnd.sym} 38670 1370 0 0 {name=s703 lab=0}
N 1800 30 1800 10 {lab=VDD}
C {devices/vdd.sym} 1800 10 0 0 {name=s704 lab=VDD}
N 1800 60 1830 60 {lab=VDD}
C {devices/vdd.sym} 1830 60 0 0 {name=s705 lab=VDD}
N 7920 30 7920 10 {lab=VDD}
C {devices/vdd.sym} 7920 10 0 0 {name=s706 lab=VDD}
N 7920 60 7950 60 {lab=VDD}
C {devices/vdd.sym} 7950 60 0 0 {name=s707 lab=VDD}
N 36760 30 36760 10 {lab=VDD}
C {devices/vdd.sym} 36760 10 0 0 {name=s708 lab=VDD}
N 36760 60 36790 60 {lab=VDD}
C {devices/vdd.sym} 36790 60 0 0 {name=s709 lab=VDD}
N 36760 210 36790 210 {lab=VDD}
C {devices/vdd.sym} 36790 210 0 0 {name=s710 lab=VDD}
N 37160 210 37190 210 {lab=VDD}
C {devices/vdd.sym} 37190 210 0 0 {name=s711 lab=VDD}
N 36960 30 36960 10 {lab=VDD}
C {devices/vdd.sym} 36960 10 0 0 {name=s712 lab=VDD}
N 36960 60 36990 60 {lab=VDD}
C {devices/vdd.sym} 36990 60 0 0 {name=s713 lab=VDD}
N 37160 30 37160 10 {lab=VDD}
C {devices/vdd.sym} 37160 10 0 0 {name=s714 lab=VDD}
N 37160 60 37190 60 {lab=VDD}
C {devices/vdd.sym} 37190 60 0 0 {name=s715 lab=VDD}
N 38080 30 38080 10 {lab=VDD}
C {devices/vdd.sym} 38080 10 0 0 {name=s716 lab=VDD}
N 38080 60 38110 60 {lab=VDD}
C {devices/vdd.sym} 38110 60 0 0 {name=s717 lab=VDD}
N 38080 210 38110 210 {lab=VDD}
C {devices/vdd.sym} 38110 210 0 0 {name=s718 lab=VDD}
N 38280 210 38310 210 {lab=VDD}
C {devices/vdd.sym} 38310 210 0 0 {name=s719 lab=VDD}
N 38280 30 38280 10 {lab=VDD}
C {devices/vdd.sym} 38280 10 0 0 {name=s720 lab=VDD}
N 38280 60 38310 60 {lab=VDD}
C {devices/vdd.sym} 38310 60 0 0 {name=s721 lab=VDD}
N 37520 30 37520 10 {lab=VDD}
C {devices/vdd.sym} 37520 10 0 0 {name=s722 lab=VDD}
N 37520 60 37550 60 {lab=VDD}
C {devices/vdd.sym} 37550 60 0 0 {name=s723 lab=VDD}
N 37720 30 37720 10 {lab=VDD}
C {devices/vdd.sym} 37720 10 0 0 {name=s724 lab=VDD}
N 37720 60 37750 60 {lab=VDD}
C {devices/vdd.sym} 37750 60 0 0 {name=s725 lab=VDD}
N 38640 30 38640 10 {lab=VDD}
C {devices/vdd.sym} 38640 10 0 0 {name=s726 lab=VDD}
N 38640 60 38670 60 {lab=VDD}
C {devices/vdd.sym} 38670 60 0 0 {name=s727 lab=VDD}
N 2160 1400 2160 1420 {lab=0}
C {devices/gnd.sym} 2160 1420 0 0 {name=s728 lab=0}
N 2160 1370 2190 1370 {lab=0}
C {devices/gnd.sym} 2190 1370 0 0 {name=s729 lab=0}
N 8280 1400 8280 1420 {lab=0}
C {devices/gnd.sym} 8280 1420 0 0 {name=s730 lab=0}
N 8280 1370 8310 1370 {lab=0}
C {devices/gnd.sym} 8310 1370 0 0 {name=s731 lab=0}
N 41040 1400 41040 1420 {lab=0}
C {devices/gnd.sym} 41040 1420 0 0 {name=s732 lab=0}
N 41040 1370 41070 1370 {lab=0}
C {devices/gnd.sym} 41070 1370 0 0 {name=s733 lab=0}
N 41040 1220 41070 1220 {lab=0}
C {devices/gnd.sym} 41070 1220 0 0 {name=s734 lab=0}
N 41240 1070 41270 1070 {lab=0}
C {devices/gnd.sym} 41270 1070 0 0 {name=s735 lab=0}
N 41240 1220 41270 1220 {lab=0}
C {devices/gnd.sym} 41270 1220 0 0 {name=s736 lab=0}
N 41240 1400 41240 1420 {lab=0}
C {devices/gnd.sym} 41240 1420 0 0 {name=s737 lab=0}
N 41240 1370 41270 1370 {lab=0}
C {devices/gnd.sym} 41270 1370 0 0 {name=s738 lab=0}
N 41800 1400 41800 1420 {lab=0}
C {devices/gnd.sym} 41800 1420 0 0 {name=s739 lab=0}
N 41800 1370 41830 1370 {lab=0}
C {devices/gnd.sym} 41830 1370 0 0 {name=s740 lab=0}
N 41800 1220 41830 1220 {lab=0}
C {devices/gnd.sym} 41830 1220 0 0 {name=s741 lab=0}
N 42000 1220 42030 1220 {lab=0}
C {devices/gnd.sym} 42030 1220 0 0 {name=s742 lab=0}
N 42000 1400 42000 1420 {lab=0}
C {devices/gnd.sym} 42000 1420 0 0 {name=s743 lab=0}
N 42000 1370 42030 1370 {lab=0}
C {devices/gnd.sym} 42030 1370 0 0 {name=s744 lab=0}
N 39560 1400 39560 1420 {lab=0}
C {devices/gnd.sym} 39560 1420 0 0 {name=s745 lab=0}
N 39560 1370 39590 1370 {lab=0}
C {devices/gnd.sym} 39590 1370 0 0 {name=s746 lab=0}
N 39560 1220 39590 1220 {lab=0}
C {devices/gnd.sym} 39590 1220 0 0 {name=s747 lab=0}
N 40120 1400 40120 1420 {lab=0}
C {devices/gnd.sym} 40120 1420 0 0 {name=s748 lab=0}
N 40120 1370 40150 1370 {lab=0}
C {devices/gnd.sym} 40150 1370 0 0 {name=s749 lab=0}
N 2160 30 2160 10 {lab=VDD}
C {devices/vdd.sym} 2160 10 0 0 {name=s750 lab=VDD}
N 2160 60 2190 60 {lab=VDD}
C {devices/vdd.sym} 2190 60 0 0 {name=s751 lab=VDD}
N 8280 30 8280 10 {lab=VDD}
C {devices/vdd.sym} 8280 10 0 0 {name=s752 lab=VDD}
N 8280 60 8310 60 {lab=VDD}
C {devices/vdd.sym} 8310 60 0 0 {name=s753 lab=VDD}
N 41040 30 41040 10 {lab=VDD}
C {devices/vdd.sym} 41040 10 0 0 {name=s754 lab=VDD}
N 41040 60 41070 60 {lab=VDD}
C {devices/vdd.sym} 41070 60 0 0 {name=s755 lab=VDD}
N 41040 210 41070 210 {lab=VDD}
C {devices/vdd.sym} 41070 210 0 0 {name=s756 lab=VDD}
N 41440 210 41470 210 {lab=VDD}
C {devices/vdd.sym} 41470 210 0 0 {name=s757 lab=VDD}
N 41240 30 41240 10 {lab=VDD}
C {devices/vdd.sym} 41240 10 0 0 {name=s758 lab=VDD}
N 41240 60 41270 60 {lab=VDD}
C {devices/vdd.sym} 41270 60 0 0 {name=s759 lab=VDD}
N 41440 30 41440 10 {lab=VDD}
C {devices/vdd.sym} 41440 10 0 0 {name=s760 lab=VDD}
N 41440 60 41470 60 {lab=VDD}
C {devices/vdd.sym} 41470 60 0 0 {name=s761 lab=VDD}
N 41800 30 41800 10 {lab=VDD}
C {devices/vdd.sym} 41800 10 0 0 {name=s762 lab=VDD}
N 41800 60 41830 60 {lab=VDD}
C {devices/vdd.sym} 41830 60 0 0 {name=s763 lab=VDD}
N 41800 210 41830 210 {lab=VDD}
C {devices/vdd.sym} 41830 210 0 0 {name=s764 lab=VDD}
N 42000 210 42030 210 {lab=VDD}
C {devices/vdd.sym} 42030 210 0 0 {name=s765 lab=VDD}
N 42000 30 42000 10 {lab=VDD}
C {devices/vdd.sym} 42000 10 0 0 {name=s766 lab=VDD}
N 42000 60 42030 60 {lab=VDD}
C {devices/vdd.sym} 42030 60 0 0 {name=s767 lab=VDD}
N 39560 30 39560 10 {lab=VDD}
C {devices/vdd.sym} 39560 10 0 0 {name=s768 lab=VDD}
N 39560 60 39590 60 {lab=VDD}
C {devices/vdd.sym} 39590 60 0 0 {name=s769 lab=VDD}
N 39760 30 39760 10 {lab=VDD}
C {devices/vdd.sym} 39760 10 0 0 {name=s770 lab=VDD}
N 39760 60 39790 60 {lab=VDD}
C {devices/vdd.sym} 39790 60 0 0 {name=s771 lab=VDD}
N 40120 30 40120 10 {lab=VDD}
C {devices/vdd.sym} 40120 10 0 0 {name=s772 lab=VDD}
N 40120 60 40150 60 {lab=VDD}
C {devices/vdd.sym} 40150 60 0 0 {name=s773 lab=VDD}
N 2520 1400 2520 1420 {lab=0}
C {devices/gnd.sym} 2520 1420 0 0 {name=s774 lab=0}
N 2520 1370 2550 1370 {lab=0}
C {devices/gnd.sym} 2550 1370 0 0 {name=s775 lab=0}
N 8640 1400 8640 1420 {lab=0}
C {devices/gnd.sym} 8640 1420 0 0 {name=s776 lab=0}
N 8640 1370 8670 1370 {lab=0}
C {devices/gnd.sym} 8670 1370 0 0 {name=s777 lab=0}
N 45520 1400 45520 1420 {lab=0}
C {devices/gnd.sym} 45520 1420 0 0 {name=s778 lab=0}
N 45520 1370 45550 1370 {lab=0}
C {devices/gnd.sym} 45550 1370 0 0 {name=s779 lab=0}
N 45520 1220 45550 1220 {lab=0}
C {devices/gnd.sym} 45550 1220 0 0 {name=s780 lab=0}
N 45720 1070 45750 1070 {lab=0}
C {devices/gnd.sym} 45750 1070 0 0 {name=s781 lab=0}
N 45720 1220 45750 1220 {lab=0}
C {devices/gnd.sym} 45750 1220 0 0 {name=s782 lab=0}
N 45720 1400 45720 1420 {lab=0}
C {devices/gnd.sym} 45720 1420 0 0 {name=s783 lab=0}
N 45720 1370 45750 1370 {lab=0}
C {devices/gnd.sym} 45750 1370 0 0 {name=s784 lab=0}
N 46280 1400 46280 1420 {lab=0}
C {devices/gnd.sym} 46280 1420 0 0 {name=s785 lab=0}
N 46280 1370 46310 1370 {lab=0}
C {devices/gnd.sym} 46310 1370 0 0 {name=s786 lab=0}
N 46280 1220 46310 1220 {lab=0}
C {devices/gnd.sym} 46310 1220 0 0 {name=s787 lab=0}
N 46480 1220 46510 1220 {lab=0}
C {devices/gnd.sym} 46510 1220 0 0 {name=s788 lab=0}
N 46480 1400 46480 1420 {lab=0}
C {devices/gnd.sym} 46480 1420 0 0 {name=s789 lab=0}
N 46480 1370 46510 1370 {lab=0}
C {devices/gnd.sym} 46510 1370 0 0 {name=s790 lab=0}
N 42360 1400 42360 1420 {lab=0}
C {devices/gnd.sym} 42360 1420 0 0 {name=s791 lab=0}
N 42360 1370 42390 1370 {lab=0}
C {devices/gnd.sym} 42390 1370 0 0 {name=s792 lab=0}
N 42360 1220 42390 1220 {lab=0}
C {devices/gnd.sym} 42390 1220 0 0 {name=s793 lab=0}
N 42920 1400 42920 1420 {lab=0}
C {devices/gnd.sym} 42920 1420 0 0 {name=s794 lab=0}
N 42920 1370 42950 1370 {lab=0}
C {devices/gnd.sym} 42950 1370 0 0 {name=s795 lab=0}
N 2520 30 2520 10 {lab=VDD}
C {devices/vdd.sym} 2520 10 0 0 {name=s796 lab=VDD}
N 2520 60 2550 60 {lab=VDD}
C {devices/vdd.sym} 2550 60 0 0 {name=s797 lab=VDD}
N 8640 30 8640 10 {lab=VDD}
C {devices/vdd.sym} 8640 10 0 0 {name=s798 lab=VDD}
N 8640 60 8670 60 {lab=VDD}
C {devices/vdd.sym} 8670 60 0 0 {name=s799 lab=VDD}
N 45520 30 45520 10 {lab=VDD}
C {devices/vdd.sym} 45520 10 0 0 {name=s800 lab=VDD}
N 45520 60 45550 60 {lab=VDD}
C {devices/vdd.sym} 45550 60 0 0 {name=s801 lab=VDD}
N 45520 210 45550 210 {lab=VDD}
C {devices/vdd.sym} 45550 210 0 0 {name=s802 lab=VDD}
N 45920 210 45950 210 {lab=VDD}
C {devices/vdd.sym} 45950 210 0 0 {name=s803 lab=VDD}
N 45720 30 45720 10 {lab=VDD}
C {devices/vdd.sym} 45720 10 0 0 {name=s804 lab=VDD}
N 45720 60 45750 60 {lab=VDD}
C {devices/vdd.sym} 45750 60 0 0 {name=s805 lab=VDD}
N 45920 30 45920 10 {lab=VDD}
C {devices/vdd.sym} 45920 10 0 0 {name=s806 lab=VDD}
N 45920 60 45950 60 {lab=VDD}
C {devices/vdd.sym} 45950 60 0 0 {name=s807 lab=VDD}
N 46280 30 46280 10 {lab=VDD}
C {devices/vdd.sym} 46280 10 0 0 {name=s808 lab=VDD}
N 46280 60 46310 60 {lab=VDD}
C {devices/vdd.sym} 46310 60 0 0 {name=s809 lab=VDD}
N 46280 210 46310 210 {lab=VDD}
C {devices/vdd.sym} 46310 210 0 0 {name=s810 lab=VDD}
N 46480 210 46510 210 {lab=VDD}
C {devices/vdd.sym} 46510 210 0 0 {name=s811 lab=VDD}
N 46480 30 46480 10 {lab=VDD}
C {devices/vdd.sym} 46480 10 0 0 {name=s812 lab=VDD}
N 46480 60 46510 60 {lab=VDD}
C {devices/vdd.sym} 46510 60 0 0 {name=s813 lab=VDD}
N 42360 30 42360 10 {lab=VDD}
C {devices/vdd.sym} 42360 10 0 0 {name=s814 lab=VDD}
N 42360 60 42390 60 {lab=VDD}
C {devices/vdd.sym} 42390 60 0 0 {name=s815 lab=VDD}
N 42560 30 42560 10 {lab=VDD}
C {devices/vdd.sym} 42560 10 0 0 {name=s816 lab=VDD}
N 42560 60 42590 60 {lab=VDD}
C {devices/vdd.sym} 42590 60 0 0 {name=s817 lab=VDD}
N 42920 30 42920 10 {lab=VDD}
C {devices/vdd.sym} 42920 10 0 0 {name=s818 lab=VDD}
N 42920 60 42950 60 {lab=VDD}
C {devices/vdd.sym} 42950 60 0 0 {name=s819 lab=VDD}
N 2880 1400 2880 1420 {lab=0}
C {devices/gnd.sym} 2880 1420 0 0 {name=s820 lab=0}
N 2880 1370 2910 1370 {lab=0}
C {devices/gnd.sym} 2910 1370 0 0 {name=s821 lab=0}
N 9000 1400 9000 1420 {lab=0}
C {devices/gnd.sym} 9000 1420 0 0 {name=s822 lab=0}
N 9000 1370 9030 1370 {lab=0}
C {devices/gnd.sym} 9030 1370 0 0 {name=s823 lab=0}
N 46840 1400 46840 1420 {lab=0}
C {devices/gnd.sym} 46840 1420 0 0 {name=s824 lab=0}
N 46840 1370 46870 1370 {lab=0}
C {devices/gnd.sym} 46870 1370 0 0 {name=s825 lab=0}
N 46840 1220 46870 1220 {lab=0}
C {devices/gnd.sym} 46870 1220 0 0 {name=s826 lab=0}
N 47040 1070 47070 1070 {lab=0}
C {devices/gnd.sym} 47070 1070 0 0 {name=s827 lab=0}
N 47040 1220 47070 1220 {lab=0}
C {devices/gnd.sym} 47070 1220 0 0 {name=s828 lab=0}
N 47040 1400 47040 1420 {lab=0}
C {devices/gnd.sym} 47040 1420 0 0 {name=s829 lab=0}
N 47040 1370 47070 1370 {lab=0}
C {devices/gnd.sym} 47070 1370 0 0 {name=s830 lab=0}
N 48160 1400 48160 1420 {lab=0}
C {devices/gnd.sym} 48160 1420 0 0 {name=s831 lab=0}
N 48160 1370 48190 1370 {lab=0}
C {devices/gnd.sym} 48190 1370 0 0 {name=s832 lab=0}
N 48160 1220 48190 1220 {lab=0}
C {devices/gnd.sym} 48190 1220 0 0 {name=s833 lab=0}
N 48360 1220 48390 1220 {lab=0}
C {devices/gnd.sym} 48390 1220 0 0 {name=s834 lab=0}
N 48360 1400 48360 1420 {lab=0}
C {devices/gnd.sym} 48360 1420 0 0 {name=s835 lab=0}
N 48360 1370 48390 1370 {lab=0}
C {devices/gnd.sym} 48390 1370 0 0 {name=s836 lab=0}
N 47600 1400 47600 1420 {lab=0}
C {devices/gnd.sym} 47600 1420 0 0 {name=s837 lab=0}
N 47600 1370 47630 1370 {lab=0}
C {devices/gnd.sym} 47630 1370 0 0 {name=s838 lab=0}
N 47600 1220 47630 1220 {lab=0}
C {devices/gnd.sym} 47630 1220 0 0 {name=s839 lab=0}
N 48720 1400 48720 1420 {lab=0}
C {devices/gnd.sym} 48720 1420 0 0 {name=s840 lab=0}
N 48720 1370 48750 1370 {lab=0}
C {devices/gnd.sym} 48750 1370 0 0 {name=s841 lab=0}
N 2880 30 2880 10 {lab=VDD}
C {devices/vdd.sym} 2880 10 0 0 {name=s842 lab=VDD}
N 2880 60 2910 60 {lab=VDD}
C {devices/vdd.sym} 2910 60 0 0 {name=s843 lab=VDD}
N 9000 30 9000 10 {lab=VDD}
C {devices/vdd.sym} 9000 10 0 0 {name=s844 lab=VDD}
N 9000 60 9030 60 {lab=VDD}
C {devices/vdd.sym} 9030 60 0 0 {name=s845 lab=VDD}
N 46840 30 46840 10 {lab=VDD}
C {devices/vdd.sym} 46840 10 0 0 {name=s846 lab=VDD}
N 46840 60 46870 60 {lab=VDD}
C {devices/vdd.sym} 46870 60 0 0 {name=s847 lab=VDD}
N 46840 210 46870 210 {lab=VDD}
C {devices/vdd.sym} 46870 210 0 0 {name=s848 lab=VDD}
N 47240 210 47270 210 {lab=VDD}
C {devices/vdd.sym} 47270 210 0 0 {name=s849 lab=VDD}
N 47040 30 47040 10 {lab=VDD}
C {devices/vdd.sym} 47040 10 0 0 {name=s850 lab=VDD}
N 47040 60 47070 60 {lab=VDD}
C {devices/vdd.sym} 47070 60 0 0 {name=s851 lab=VDD}
N 47240 30 47240 10 {lab=VDD}
C {devices/vdd.sym} 47240 10 0 0 {name=s852 lab=VDD}
N 47240 60 47270 60 {lab=VDD}
C {devices/vdd.sym} 47270 60 0 0 {name=s853 lab=VDD}
N 48160 30 48160 10 {lab=VDD}
C {devices/vdd.sym} 48160 10 0 0 {name=s854 lab=VDD}
N 48160 60 48190 60 {lab=VDD}
C {devices/vdd.sym} 48190 60 0 0 {name=s855 lab=VDD}
N 48160 210 48190 210 {lab=VDD}
C {devices/vdd.sym} 48190 210 0 0 {name=s856 lab=VDD}
N 48360 210 48390 210 {lab=VDD}
C {devices/vdd.sym} 48390 210 0 0 {name=s857 lab=VDD}
N 48360 30 48360 10 {lab=VDD}
C {devices/vdd.sym} 48360 10 0 0 {name=s858 lab=VDD}
N 48360 60 48390 60 {lab=VDD}
C {devices/vdd.sym} 48390 60 0 0 {name=s859 lab=VDD}
N 47600 30 47600 10 {lab=VDD}
C {devices/vdd.sym} 47600 10 0 0 {name=s860 lab=VDD}
N 47600 60 47630 60 {lab=VDD}
C {devices/vdd.sym} 47630 60 0 0 {name=s861 lab=VDD}
N 47800 30 47800 10 {lab=VDD}
C {devices/vdd.sym} 47800 10 0 0 {name=s862 lab=VDD}
N 47800 60 47830 60 {lab=VDD}
C {devices/vdd.sym} 47830 60 0 0 {name=s863 lab=VDD}
N 48720 30 48720 10 {lab=VDD}
C {devices/vdd.sym} 48720 10 0 0 {name=s864 lab=VDD}
N 48720 60 48750 60 {lab=VDD}
C {devices/vdd.sym} 48750 60 0 0 {name=s865 lab=VDD}
N 3240 1400 3240 1420 {lab=0}
C {devices/gnd.sym} 3240 1420 0 0 {name=s866 lab=0}
N 3240 1370 3270 1370 {lab=0}
C {devices/gnd.sym} 3270 1370 0 0 {name=s867 lab=0}
N 9360 1400 9360 1420 {lab=0}
C {devices/gnd.sym} 9360 1420 0 0 {name=s868 lab=0}
N 9360 1370 9390 1370 {lab=0}
C {devices/gnd.sym} 9390 1370 0 0 {name=s869 lab=0}
N 51160 1400 51160 1420 {lab=0}
C {devices/gnd.sym} 51160 1420 0 0 {name=s870 lab=0}
N 51160 1370 51190 1370 {lab=0}
C {devices/gnd.sym} 51190 1370 0 0 {name=s871 lab=0}
N 51160 1220 51190 1220 {lab=0}
C {devices/gnd.sym} 51190 1220 0 0 {name=s872 lab=0}
N 51360 1070 51390 1070 {lab=0}
C {devices/gnd.sym} 51390 1070 0 0 {name=s873 lab=0}
N 51360 1220 51390 1220 {lab=0}
C {devices/gnd.sym} 51390 1220 0 0 {name=s874 lab=0}
N 51360 1400 51360 1420 {lab=0}
C {devices/gnd.sym} 51360 1420 0 0 {name=s875 lab=0}
N 51360 1370 51390 1370 {lab=0}
C {devices/gnd.sym} 51390 1370 0 0 {name=s876 lab=0}
N 52480 1400 52480 1420 {lab=0}
C {devices/gnd.sym} 52480 1420 0 0 {name=s877 lab=0}
N 52480 1370 52510 1370 {lab=0}
C {devices/gnd.sym} 52510 1370 0 0 {name=s878 lab=0}
N 52480 1220 52510 1220 {lab=0}
C {devices/gnd.sym} 52510 1220 0 0 {name=s879 lab=0}
N 52680 1220 52710 1220 {lab=0}
C {devices/gnd.sym} 52710 1220 0 0 {name=s880 lab=0}
N 52680 1400 52680 1420 {lab=0}
C {devices/gnd.sym} 52680 1420 0 0 {name=s881 lab=0}
N 52680 1370 52710 1370 {lab=0}
C {devices/gnd.sym} 52710 1370 0 0 {name=s882 lab=0}
N 51920 1400 51920 1420 {lab=0}
C {devices/gnd.sym} 51920 1420 0 0 {name=s883 lab=0}
N 51920 1370 51950 1370 {lab=0}
C {devices/gnd.sym} 51950 1370 0 0 {name=s884 lab=0}
N 51920 1220 51950 1220 {lab=0}
C {devices/gnd.sym} 51950 1220 0 0 {name=s885 lab=0}
N 53040 1400 53040 1420 {lab=0}
C {devices/gnd.sym} 53040 1420 0 0 {name=s886 lab=0}
N 53040 1370 53070 1370 {lab=0}
C {devices/gnd.sym} 53070 1370 0 0 {name=s887 lab=0}
N 3240 30 3240 10 {lab=VDD}
C {devices/vdd.sym} 3240 10 0 0 {name=s888 lab=VDD}
N 3240 60 3270 60 {lab=VDD}
C {devices/vdd.sym} 3270 60 0 0 {name=s889 lab=VDD}
N 9360 30 9360 10 {lab=VDD}
C {devices/vdd.sym} 9360 10 0 0 {name=s890 lab=VDD}
N 9360 60 9390 60 {lab=VDD}
C {devices/vdd.sym} 9390 60 0 0 {name=s891 lab=VDD}
N 51160 30 51160 10 {lab=VDD}
C {devices/vdd.sym} 51160 10 0 0 {name=s892 lab=VDD}
N 51160 60 51190 60 {lab=VDD}
C {devices/vdd.sym} 51190 60 0 0 {name=s893 lab=VDD}
N 51160 210 51190 210 {lab=VDD}
C {devices/vdd.sym} 51190 210 0 0 {name=s894 lab=VDD}
N 51560 210 51590 210 {lab=VDD}
C {devices/vdd.sym} 51590 210 0 0 {name=s895 lab=VDD}
N 51360 30 51360 10 {lab=VDD}
C {devices/vdd.sym} 51360 10 0 0 {name=s896 lab=VDD}
N 51360 60 51390 60 {lab=VDD}
C {devices/vdd.sym} 51390 60 0 0 {name=s897 lab=VDD}
N 51560 30 51560 10 {lab=VDD}
C {devices/vdd.sym} 51560 10 0 0 {name=s898 lab=VDD}
N 51560 60 51590 60 {lab=VDD}
C {devices/vdd.sym} 51590 60 0 0 {name=s899 lab=VDD}
N 52480 30 52480 10 {lab=VDD}
C {devices/vdd.sym} 52480 10 0 0 {name=s900 lab=VDD}
N 52480 60 52510 60 {lab=VDD}
C {devices/vdd.sym} 52510 60 0 0 {name=s901 lab=VDD}
N 52480 210 52510 210 {lab=VDD}
C {devices/vdd.sym} 52510 210 0 0 {name=s902 lab=VDD}
N 52680 210 52710 210 {lab=VDD}
C {devices/vdd.sym} 52710 210 0 0 {name=s903 lab=VDD}
N 52680 30 52680 10 {lab=VDD}
C {devices/vdd.sym} 52680 10 0 0 {name=s904 lab=VDD}
N 52680 60 52710 60 {lab=VDD}
C {devices/vdd.sym} 52710 60 0 0 {name=s905 lab=VDD}
N 51920 30 51920 10 {lab=VDD}
C {devices/vdd.sym} 51920 10 0 0 {name=s906 lab=VDD}
N 51920 60 51950 60 {lab=VDD}
C {devices/vdd.sym} 51950 60 0 0 {name=s907 lab=VDD}
N 52120 30 52120 10 {lab=VDD}
C {devices/vdd.sym} 52120 10 0 0 {name=s908 lab=VDD}
N 52120 60 52150 60 {lab=VDD}
C {devices/vdd.sym} 52150 60 0 0 {name=s909 lab=VDD}
N 53040 30 53040 10 {lab=VDD}
C {devices/vdd.sym} 53040 10 0 0 {name=s910 lab=VDD}
N 53040 60 53070 60 {lab=VDD}
C {devices/vdd.sym} 53070 60 0 0 {name=s911 lab=VDD}
N 3600 1400 3600 1420 {lab=0}
C {devices/gnd.sym} 3600 1420 0 0 {name=s912 lab=0}
N 3600 1370 3630 1370 {lab=0}
C {devices/gnd.sym} 3630 1370 0 0 {name=s913 lab=0}
N 9720 1400 9720 1420 {lab=0}
C {devices/gnd.sym} 9720 1420 0 0 {name=s914 lab=0}
N 9720 1370 9750 1370 {lab=0}
C {devices/gnd.sym} 9750 1370 0 0 {name=s915 lab=0}
N 56720 1400 56720 1420 {lab=0}
C {devices/gnd.sym} 56720 1420 0 0 {name=s916 lab=0}
N 56720 1370 56750 1370 {lab=0}
C {devices/gnd.sym} 56750 1370 0 0 {name=s917 lab=0}
N 56720 1220 56750 1220 {lab=0}
C {devices/gnd.sym} 56750 1220 0 0 {name=s918 lab=0}
N 56920 1070 56950 1070 {lab=0}
C {devices/gnd.sym} 56950 1070 0 0 {name=s919 lab=0}
N 56920 1220 56950 1220 {lab=0}
C {devices/gnd.sym} 56950 1220 0 0 {name=s920 lab=0}
N 56920 1400 56920 1420 {lab=0}
C {devices/gnd.sym} 56920 1420 0 0 {name=s921 lab=0}
N 56920 1370 56950 1370 {lab=0}
C {devices/gnd.sym} 56950 1370 0 0 {name=s922 lab=0}
N 57480 1400 57480 1420 {lab=0}
C {devices/gnd.sym} 57480 1420 0 0 {name=s923 lab=0}
N 57480 1370 57510 1370 {lab=0}
C {devices/gnd.sym} 57510 1370 0 0 {name=s924 lab=0}
N 57480 1220 57510 1220 {lab=0}
C {devices/gnd.sym} 57510 1220 0 0 {name=s925 lab=0}
N 57680 1220 57710 1220 {lab=0}
C {devices/gnd.sym} 57710 1220 0 0 {name=s926 lab=0}
N 57680 1400 57680 1420 {lab=0}
C {devices/gnd.sym} 57680 1420 0 0 {name=s927 lab=0}
N 57680 1370 57710 1370 {lab=0}
C {devices/gnd.sym} 57710 1370 0 0 {name=s928 lab=0}
N 54520 1400 54520 1420 {lab=0}
C {devices/gnd.sym} 54520 1420 0 0 {name=s929 lab=0}
N 54520 1370 54550 1370 {lab=0}
C {devices/gnd.sym} 54550 1370 0 0 {name=s930 lab=0}
N 54520 1220 54550 1220 {lab=0}
C {devices/gnd.sym} 54550 1220 0 0 {name=s931 lab=0}
N 55080 1400 55080 1420 {lab=0}
C {devices/gnd.sym} 55080 1420 0 0 {name=s932 lab=0}
N 55080 1370 55110 1370 {lab=0}
C {devices/gnd.sym} 55110 1370 0 0 {name=s933 lab=0}
N 3600 30 3600 10 {lab=VDD}
C {devices/vdd.sym} 3600 10 0 0 {name=s934 lab=VDD}
N 3600 60 3630 60 {lab=VDD}
C {devices/vdd.sym} 3630 60 0 0 {name=s935 lab=VDD}
N 9720 30 9720 10 {lab=VDD}
C {devices/vdd.sym} 9720 10 0 0 {name=s936 lab=VDD}
N 9720 60 9750 60 {lab=VDD}
C {devices/vdd.sym} 9750 60 0 0 {name=s937 lab=VDD}
N 56720 30 56720 10 {lab=VDD}
C {devices/vdd.sym} 56720 10 0 0 {name=s938 lab=VDD}
N 56720 60 56750 60 {lab=VDD}
C {devices/vdd.sym} 56750 60 0 0 {name=s939 lab=VDD}
N 56720 210 56750 210 {lab=VDD}
C {devices/vdd.sym} 56750 210 0 0 {name=s940 lab=VDD}
N 57120 210 57150 210 {lab=VDD}
C {devices/vdd.sym} 57150 210 0 0 {name=s941 lab=VDD}
N 56920 30 56920 10 {lab=VDD}
C {devices/vdd.sym} 56920 10 0 0 {name=s942 lab=VDD}
N 56920 60 56950 60 {lab=VDD}
C {devices/vdd.sym} 56950 60 0 0 {name=s943 lab=VDD}
N 57120 30 57120 10 {lab=VDD}
C {devices/vdd.sym} 57120 10 0 0 {name=s944 lab=VDD}
N 57120 60 57150 60 {lab=VDD}
C {devices/vdd.sym} 57150 60 0 0 {name=s945 lab=VDD}
N 57480 30 57480 10 {lab=VDD}
C {devices/vdd.sym} 57480 10 0 0 {name=s946 lab=VDD}
N 57480 60 57510 60 {lab=VDD}
C {devices/vdd.sym} 57510 60 0 0 {name=s947 lab=VDD}
N 57480 210 57510 210 {lab=VDD}
C {devices/vdd.sym} 57510 210 0 0 {name=s948 lab=VDD}
N 57680 210 57710 210 {lab=VDD}
C {devices/vdd.sym} 57710 210 0 0 {name=s949 lab=VDD}
N 57680 30 57680 10 {lab=VDD}
C {devices/vdd.sym} 57680 10 0 0 {name=s950 lab=VDD}
N 57680 60 57710 60 {lab=VDD}
C {devices/vdd.sym} 57710 60 0 0 {name=s951 lab=VDD}
N 54520 30 54520 10 {lab=VDD}
C {devices/vdd.sym} 54520 10 0 0 {name=s952 lab=VDD}
N 54520 60 54550 60 {lab=VDD}
C {devices/vdd.sym} 54550 60 0 0 {name=s953 lab=VDD}
N 54720 30 54720 10 {lab=VDD}
C {devices/vdd.sym} 54720 10 0 0 {name=s954 lab=VDD}
N 54720 60 54750 60 {lab=VDD}
C {devices/vdd.sym} 54750 60 0 0 {name=s955 lab=VDD}
N 55080 30 55080 10 {lab=VDD}
C {devices/vdd.sym} 55080 10 0 0 {name=s956 lab=VDD}
N 55080 60 55110 60 {lab=VDD}
C {devices/vdd.sym} 55110 60 0 0 {name=s957 lab=VDD}
N 3960 1400 3960 1420 {lab=0}
C {devices/gnd.sym} 3960 1420 0 0 {name=s958 lab=0}
N 3960 1370 3990 1370 {lab=0}
C {devices/gnd.sym} 3990 1370 0 0 {name=s959 lab=0}
N 10080 1400 10080 1420 {lab=0}
C {devices/gnd.sym} 10080 1420 0 0 {name=s960 lab=0}
N 10080 1370 10110 1370 {lab=0}
C {devices/gnd.sym} 10110 1370 0 0 {name=s961 lab=0}
N 58040 1400 58040 1420 {lab=0}
C {devices/gnd.sym} 58040 1420 0 0 {name=s962 lab=0}
N 58040 1370 58070 1370 {lab=0}
C {devices/gnd.sym} 58070 1370 0 0 {name=s963 lab=0}
N 58040 1220 58070 1220 {lab=0}
C {devices/gnd.sym} 58070 1220 0 0 {name=s964 lab=0}
N 58240 1070 58270 1070 {lab=0}
C {devices/gnd.sym} 58270 1070 0 0 {name=s965 lab=0}
N 58240 1220 58270 1220 {lab=0}
C {devices/gnd.sym} 58270 1220 0 0 {name=s966 lab=0}
N 58240 1400 58240 1420 {lab=0}
C {devices/gnd.sym} 58240 1420 0 0 {name=s967 lab=0}
N 58240 1370 58270 1370 {lab=0}
C {devices/gnd.sym} 58270 1370 0 0 {name=s968 lab=0}
N 59360 1400 59360 1420 {lab=0}
C {devices/gnd.sym} 59360 1420 0 0 {name=s969 lab=0}
N 59360 1370 59390 1370 {lab=0}
C {devices/gnd.sym} 59390 1370 0 0 {name=s970 lab=0}
N 59360 1220 59390 1220 {lab=0}
C {devices/gnd.sym} 59390 1220 0 0 {name=s971 lab=0}
N 59560 1220 59590 1220 {lab=0}
C {devices/gnd.sym} 59590 1220 0 0 {name=s972 lab=0}
N 59560 1400 59560 1420 {lab=0}
C {devices/gnd.sym} 59560 1420 0 0 {name=s973 lab=0}
N 59560 1370 59590 1370 {lab=0}
C {devices/gnd.sym} 59590 1370 0 0 {name=s974 lab=0}
N 58800 1400 58800 1420 {lab=0}
C {devices/gnd.sym} 58800 1420 0 0 {name=s975 lab=0}
N 58800 1370 58830 1370 {lab=0}
C {devices/gnd.sym} 58830 1370 0 0 {name=s976 lab=0}
N 58800 1220 58830 1220 {lab=0}
C {devices/gnd.sym} 58830 1220 0 0 {name=s977 lab=0}
N 59920 1400 59920 1420 {lab=0}
C {devices/gnd.sym} 59920 1420 0 0 {name=s978 lab=0}
N 59920 1370 59950 1370 {lab=0}
C {devices/gnd.sym} 59950 1370 0 0 {name=s979 lab=0}
N 3960 30 3960 10 {lab=VDD}
C {devices/vdd.sym} 3960 10 0 0 {name=s980 lab=VDD}
N 3960 60 3990 60 {lab=VDD}
C {devices/vdd.sym} 3990 60 0 0 {name=s981 lab=VDD}
N 10080 30 10080 10 {lab=VDD}
C {devices/vdd.sym} 10080 10 0 0 {name=s982 lab=VDD}
N 10080 60 10110 60 {lab=VDD}
C {devices/vdd.sym} 10110 60 0 0 {name=s983 lab=VDD}
N 58040 30 58040 10 {lab=VDD}
C {devices/vdd.sym} 58040 10 0 0 {name=s984 lab=VDD}
N 58040 60 58070 60 {lab=VDD}
C {devices/vdd.sym} 58070 60 0 0 {name=s985 lab=VDD}
N 58040 210 58070 210 {lab=VDD}
C {devices/vdd.sym} 58070 210 0 0 {name=s986 lab=VDD}
N 58440 210 58470 210 {lab=VDD}
C {devices/vdd.sym} 58470 210 0 0 {name=s987 lab=VDD}
N 58240 30 58240 10 {lab=VDD}
C {devices/vdd.sym} 58240 10 0 0 {name=s988 lab=VDD}
N 58240 60 58270 60 {lab=VDD}
C {devices/vdd.sym} 58270 60 0 0 {name=s989 lab=VDD}
N 58440 30 58440 10 {lab=VDD}
C {devices/vdd.sym} 58440 10 0 0 {name=s990 lab=VDD}
N 58440 60 58470 60 {lab=VDD}
C {devices/vdd.sym} 58470 60 0 0 {name=s991 lab=VDD}
N 59360 30 59360 10 {lab=VDD}
C {devices/vdd.sym} 59360 10 0 0 {name=s992 lab=VDD}
N 59360 60 59390 60 {lab=VDD}
C {devices/vdd.sym} 59390 60 0 0 {name=s993 lab=VDD}
N 59360 210 59390 210 {lab=VDD}
C {devices/vdd.sym} 59390 210 0 0 {name=s994 lab=VDD}
N 59560 210 59590 210 {lab=VDD}
C {devices/vdd.sym} 59590 210 0 0 {name=s995 lab=VDD}
N 59560 30 59560 10 {lab=VDD}
C {devices/vdd.sym} 59560 10 0 0 {name=s996 lab=VDD}
N 59560 60 59590 60 {lab=VDD}
C {devices/vdd.sym} 59590 60 0 0 {name=s997 lab=VDD}
N 58800 30 58800 10 {lab=VDD}
C {devices/vdd.sym} 58800 10 0 0 {name=s998 lab=VDD}
N 58800 60 58830 60 {lab=VDD}
C {devices/vdd.sym} 58830 60 0 0 {name=s999 lab=VDD}
N 59000 30 59000 10 {lab=VDD}
C {devices/vdd.sym} 59000 10 0 0 {name=s1000 lab=VDD}
N 59000 60 59030 60 {lab=VDD}
C {devices/vdd.sym} 59030 60 0 0 {name=s1001 lab=VDD}
N 59920 30 59920 10 {lab=VDD}
C {devices/vdd.sym} 59920 10 0 0 {name=s1002 lab=VDD}
N 59920 60 59950 60 {lab=VDD}
C {devices/vdd.sym} 59950 60 0 0 {name=s1003 lab=VDD}
N 4320 1400 4320 1420 {lab=0}
C {devices/gnd.sym} 4320 1420 0 0 {name=s1004 lab=0}
N 4320 1370 4350 1370 {lab=0}
C {devices/gnd.sym} 4350 1370 0 0 {name=s1005 lab=0}
N 10440 1400 10440 1420 {lab=0}
C {devices/gnd.sym} 10440 1420 0 0 {name=s1006 lab=0}
N 10440 1370 10470 1370 {lab=0}
C {devices/gnd.sym} 10470 1370 0 0 {name=s1007 lab=0}
N 64760 1400 64760 1420 {lab=0}
C {devices/gnd.sym} 64760 1420 0 0 {name=s1008 lab=0}
N 64760 1370 64790 1370 {lab=0}
C {devices/gnd.sym} 64790 1370 0 0 {name=s1009 lab=0}
N 64760 1220 64790 1220 {lab=0}
C {devices/gnd.sym} 64790 1220 0 0 {name=s1010 lab=0}
N 64960 1070 64990 1070 {lab=0}
C {devices/gnd.sym} 64990 1070 0 0 {name=s1011 lab=0}
N 64960 1220 64990 1220 {lab=0}
C {devices/gnd.sym} 64990 1220 0 0 {name=s1012 lab=0}
N 64960 1400 64960 1420 {lab=0}
C {devices/gnd.sym} 64960 1420 0 0 {name=s1013 lab=0}
N 64960 1370 64990 1370 {lab=0}
C {devices/gnd.sym} 64990 1370 0 0 {name=s1014 lab=0}
N 65520 1400 65520 1420 {lab=0}
C {devices/gnd.sym} 65520 1420 0 0 {name=s1015 lab=0}
N 65520 1370 65550 1370 {lab=0}
C {devices/gnd.sym} 65550 1370 0 0 {name=s1016 lab=0}
N 65520 1220 65550 1220 {lab=0}
C {devices/gnd.sym} 65550 1220 0 0 {name=s1017 lab=0}
N 65720 1220 65750 1220 {lab=0}
C {devices/gnd.sym} 65750 1220 0 0 {name=s1018 lab=0}
N 65720 1400 65720 1420 {lab=0}
C {devices/gnd.sym} 65720 1420 0 0 {name=s1019 lab=0}
N 65720 1370 65750 1370 {lab=0}
C {devices/gnd.sym} 65750 1370 0 0 {name=s1020 lab=0}
N 61400 1400 61400 1420 {lab=0}
C {devices/gnd.sym} 61400 1420 0 0 {name=s1021 lab=0}
N 61400 1370 61430 1370 {lab=0}
C {devices/gnd.sym} 61430 1370 0 0 {name=s1022 lab=0}
N 61400 1220 61430 1220 {lab=0}
C {devices/gnd.sym} 61430 1220 0 0 {name=s1023 lab=0}
N 61960 1400 61960 1420 {lab=0}
C {devices/gnd.sym} 61960 1420 0 0 {name=s1024 lab=0}
N 61960 1370 61990 1370 {lab=0}
C {devices/gnd.sym} 61990 1370 0 0 {name=s1025 lab=0}
N 4320 30 4320 10 {lab=VDD}
C {devices/vdd.sym} 4320 10 0 0 {name=s1026 lab=VDD}
N 4320 60 4350 60 {lab=VDD}
C {devices/vdd.sym} 4350 60 0 0 {name=s1027 lab=VDD}
N 10440 30 10440 10 {lab=VDD}
C {devices/vdd.sym} 10440 10 0 0 {name=s1028 lab=VDD}
N 10440 60 10470 60 {lab=VDD}
C {devices/vdd.sym} 10470 60 0 0 {name=s1029 lab=VDD}
N 64760 30 64760 10 {lab=VDD}
C {devices/vdd.sym} 64760 10 0 0 {name=s1030 lab=VDD}
N 64760 60 64790 60 {lab=VDD}
C {devices/vdd.sym} 64790 60 0 0 {name=s1031 lab=VDD}
N 64760 210 64790 210 {lab=VDD}
C {devices/vdd.sym} 64790 210 0 0 {name=s1032 lab=VDD}
N 65160 210 65190 210 {lab=VDD}
C {devices/vdd.sym} 65190 210 0 0 {name=s1033 lab=VDD}
N 64960 30 64960 10 {lab=VDD}
C {devices/vdd.sym} 64960 10 0 0 {name=s1034 lab=VDD}
N 64960 60 64990 60 {lab=VDD}
C {devices/vdd.sym} 64990 60 0 0 {name=s1035 lab=VDD}
N 65160 30 65160 10 {lab=VDD}
C {devices/vdd.sym} 65160 10 0 0 {name=s1036 lab=VDD}
N 65160 60 65190 60 {lab=VDD}
C {devices/vdd.sym} 65190 60 0 0 {name=s1037 lab=VDD}
N 65520 30 65520 10 {lab=VDD}
C {devices/vdd.sym} 65520 10 0 0 {name=s1038 lab=VDD}
N 65520 60 65550 60 {lab=VDD}
C {devices/vdd.sym} 65550 60 0 0 {name=s1039 lab=VDD}
N 65520 210 65550 210 {lab=VDD}
C {devices/vdd.sym} 65550 210 0 0 {name=s1040 lab=VDD}
N 65720 210 65750 210 {lab=VDD}
C {devices/vdd.sym} 65750 210 0 0 {name=s1041 lab=VDD}
N 65720 30 65720 10 {lab=VDD}
C {devices/vdd.sym} 65720 10 0 0 {name=s1042 lab=VDD}
N 65720 60 65750 60 {lab=VDD}
C {devices/vdd.sym} 65750 60 0 0 {name=s1043 lab=VDD}
N 61400 30 61400 10 {lab=VDD}
C {devices/vdd.sym} 61400 10 0 0 {name=s1044 lab=VDD}
N 61400 60 61430 60 {lab=VDD}
C {devices/vdd.sym} 61430 60 0 0 {name=s1045 lab=VDD}
N 61600 30 61600 10 {lab=VDD}
C {devices/vdd.sym} 61600 10 0 0 {name=s1046 lab=VDD}
N 61600 60 61630 60 {lab=VDD}
C {devices/vdd.sym} 61630 60 0 0 {name=s1047 lab=VDD}
N 61960 30 61960 10 {lab=VDD}
C {devices/vdd.sym} 61960 10 0 0 {name=s1048 lab=VDD}
N 61960 60 61990 60 {lab=VDD}
C {devices/vdd.sym} 61990 60 0 0 {name=s1049 lab=VDD}
N 4680 1400 4680 1420 {lab=0}
C {devices/gnd.sym} 4680 1420 0 0 {name=s1050 lab=0}
N 4680 1370 4710 1370 {lab=0}
C {devices/gnd.sym} 4710 1370 0 0 {name=s1051 lab=0}
N 10800 1400 10800 1420 {lab=0}
C {devices/gnd.sym} 10800 1420 0 0 {name=s1052 lab=0}
N 10800 1370 10830 1370 {lab=0}
C {devices/gnd.sym} 10830 1370 0 0 {name=s1053 lab=0}
N 68880 1400 68880 1420 {lab=0}
C {devices/gnd.sym} 68880 1420 0 0 {name=s1054 lab=0}
N 68880 1370 68910 1370 {lab=0}
C {devices/gnd.sym} 68910 1370 0 0 {name=s1055 lab=0}
N 68880 1220 68910 1220 {lab=0}
C {devices/gnd.sym} 68910 1220 0 0 {name=s1056 lab=0}
N 69080 1070 69110 1070 {lab=0}
C {devices/gnd.sym} 69110 1070 0 0 {name=s1057 lab=0}
N 69080 1220 69110 1220 {lab=0}
C {devices/gnd.sym} 69110 1220 0 0 {name=s1058 lab=0}
N 69080 1400 69080 1420 {lab=0}
C {devices/gnd.sym} 69080 1420 0 0 {name=s1059 lab=0}
N 69080 1370 69110 1370 {lab=0}
C {devices/gnd.sym} 69110 1370 0 0 {name=s1060 lab=0}
N 69640 1400 69640 1420 {lab=0}
C {devices/gnd.sym} 69640 1420 0 0 {name=s1061 lab=0}
N 69640 1370 69670 1370 {lab=0}
C {devices/gnd.sym} 69670 1370 0 0 {name=s1062 lab=0}
N 69640 1220 69670 1220 {lab=0}
C {devices/gnd.sym} 69670 1220 0 0 {name=s1063 lab=0}
N 69840 1220 69870 1220 {lab=0}
C {devices/gnd.sym} 69870 1220 0 0 {name=s1064 lab=0}
N 69840 1400 69840 1420 {lab=0}
C {devices/gnd.sym} 69840 1420 0 0 {name=s1065 lab=0}
N 69840 1370 69870 1370 {lab=0}
C {devices/gnd.sym} 69870 1370 0 0 {name=s1066 lab=0}
N 66080 1400 66080 1420 {lab=0}
C {devices/gnd.sym} 66080 1420 0 0 {name=s1067 lab=0}
N 66080 1370 66110 1370 {lab=0}
C {devices/gnd.sym} 66110 1370 0 0 {name=s1068 lab=0}
N 66080 1220 66110 1220 {lab=0}
C {devices/gnd.sym} 66110 1220 0 0 {name=s1069 lab=0}
N 66640 1400 66640 1420 {lab=0}
C {devices/gnd.sym} 66640 1420 0 0 {name=s1070 lab=0}
N 66640 1370 66670 1370 {lab=0}
C {devices/gnd.sym} 66670 1370 0 0 {name=s1071 lab=0}
N 4680 30 4680 10 {lab=VDD}
C {devices/vdd.sym} 4680 10 0 0 {name=s1072 lab=VDD}
N 4680 60 4710 60 {lab=VDD}
C {devices/vdd.sym} 4710 60 0 0 {name=s1073 lab=VDD}
N 10800 30 10800 10 {lab=VDD}
C {devices/vdd.sym} 10800 10 0 0 {name=s1074 lab=VDD}
N 10800 60 10830 60 {lab=VDD}
C {devices/vdd.sym} 10830 60 0 0 {name=s1075 lab=VDD}
N 68880 30 68880 10 {lab=VDD}
C {devices/vdd.sym} 68880 10 0 0 {name=s1076 lab=VDD}
N 68880 60 68910 60 {lab=VDD}
C {devices/vdd.sym} 68910 60 0 0 {name=s1077 lab=VDD}
N 68880 210 68910 210 {lab=VDD}
C {devices/vdd.sym} 68910 210 0 0 {name=s1078 lab=VDD}
N 69280 210 69310 210 {lab=VDD}
C {devices/vdd.sym} 69310 210 0 0 {name=s1079 lab=VDD}
N 69080 30 69080 10 {lab=VDD}
C {devices/vdd.sym} 69080 10 0 0 {name=s1080 lab=VDD}
N 69080 60 69110 60 {lab=VDD}
C {devices/vdd.sym} 69110 60 0 0 {name=s1081 lab=VDD}
N 69280 30 69280 10 {lab=VDD}
C {devices/vdd.sym} 69280 10 0 0 {name=s1082 lab=VDD}
N 69280 60 69310 60 {lab=VDD}
C {devices/vdd.sym} 69310 60 0 0 {name=s1083 lab=VDD}
N 69640 30 69640 10 {lab=VDD}
C {devices/vdd.sym} 69640 10 0 0 {name=s1084 lab=VDD}
N 69640 60 69670 60 {lab=VDD}
C {devices/vdd.sym} 69670 60 0 0 {name=s1085 lab=VDD}
N 69640 210 69670 210 {lab=VDD}
C {devices/vdd.sym} 69670 210 0 0 {name=s1086 lab=VDD}
N 69840 210 69870 210 {lab=VDD}
C {devices/vdd.sym} 69870 210 0 0 {name=s1087 lab=VDD}
N 69840 30 69840 10 {lab=VDD}
C {devices/vdd.sym} 69840 10 0 0 {name=s1088 lab=VDD}
N 69840 60 69870 60 {lab=VDD}
C {devices/vdd.sym} 69870 60 0 0 {name=s1089 lab=VDD}
N 66080 30 66080 10 {lab=VDD}
C {devices/vdd.sym} 66080 10 0 0 {name=s1090 lab=VDD}
N 66080 60 66110 60 {lab=VDD}
C {devices/vdd.sym} 66110 60 0 0 {name=s1091 lab=VDD}
N 66280 30 66280 10 {lab=VDD}
C {devices/vdd.sym} 66280 10 0 0 {name=s1092 lab=VDD}
N 66280 60 66310 60 {lab=VDD}
C {devices/vdd.sym} 66310 60 0 0 {name=s1093 lab=VDD}
N 66640 30 66640 10 {lab=VDD}
C {devices/vdd.sym} 66640 10 0 0 {name=s1094 lab=VDD}
N 66640 60 66670 60 {lab=VDD}
C {devices/vdd.sym} 66670 60 0 0 {name=s1095 lab=VDD}
N 5040 1400 5040 1420 {lab=0}
C {devices/gnd.sym} 5040 1420 0 0 {name=s1096 lab=0}
N 5040 1370 5070 1370 {lab=0}
C {devices/gnd.sym} 5070 1370 0 0 {name=s1097 lab=0}
N 11160 1400 11160 1420 {lab=0}
C {devices/gnd.sym} 11160 1420 0 0 {name=s1098 lab=0}
N 11160 1370 11190 1370 {lab=0}
C {devices/gnd.sym} 11190 1370 0 0 {name=s1099 lab=0}
N 73360 1400 73360 1420 {lab=0}
C {devices/gnd.sym} 73360 1420 0 0 {name=s1100 lab=0}
N 73360 1370 73390 1370 {lab=0}
C {devices/gnd.sym} 73390 1370 0 0 {name=s1101 lab=0}
N 73360 1220 73390 1220 {lab=0}
C {devices/gnd.sym} 73390 1220 0 0 {name=s1102 lab=0}
N 73560 1070 73590 1070 {lab=0}
C {devices/gnd.sym} 73590 1070 0 0 {name=s1103 lab=0}
N 73560 1220 73590 1220 {lab=0}
C {devices/gnd.sym} 73590 1220 0 0 {name=s1104 lab=0}
N 73560 1400 73560 1420 {lab=0}
C {devices/gnd.sym} 73560 1420 0 0 {name=s1105 lab=0}
N 73560 1370 73590 1370 {lab=0}
C {devices/gnd.sym} 73590 1370 0 0 {name=s1106 lab=0}
N 74120 1400 74120 1420 {lab=0}
C {devices/gnd.sym} 74120 1420 0 0 {name=s1107 lab=0}
N 74120 1370 74150 1370 {lab=0}
C {devices/gnd.sym} 74150 1370 0 0 {name=s1108 lab=0}
N 74120 1220 74150 1220 {lab=0}
C {devices/gnd.sym} 74150 1220 0 0 {name=s1109 lab=0}
N 74320 1220 74350 1220 {lab=0}
C {devices/gnd.sym} 74350 1220 0 0 {name=s1110 lab=0}
N 74320 1400 74320 1420 {lab=0}
C {devices/gnd.sym} 74320 1420 0 0 {name=s1111 lab=0}
N 74320 1370 74350 1370 {lab=0}
C {devices/gnd.sym} 74350 1370 0 0 {name=s1112 lab=0}
N 70200 1400 70200 1420 {lab=0}
C {devices/gnd.sym} 70200 1420 0 0 {name=s1113 lab=0}
N 70200 1370 70230 1370 {lab=0}
C {devices/gnd.sym} 70230 1370 0 0 {name=s1114 lab=0}
N 70200 1220 70230 1220 {lab=0}
C {devices/gnd.sym} 70230 1220 0 0 {name=s1115 lab=0}
N 70760 1400 70760 1420 {lab=0}
C {devices/gnd.sym} 70760 1420 0 0 {name=s1116 lab=0}
N 70760 1370 70790 1370 {lab=0}
C {devices/gnd.sym} 70790 1370 0 0 {name=s1117 lab=0}
N 5040 30 5040 10 {lab=VDD}
C {devices/vdd.sym} 5040 10 0 0 {name=s1118 lab=VDD}
N 5040 60 5070 60 {lab=VDD}
C {devices/vdd.sym} 5070 60 0 0 {name=s1119 lab=VDD}
N 11160 30 11160 10 {lab=VDD}
C {devices/vdd.sym} 11160 10 0 0 {name=s1120 lab=VDD}
N 11160 60 11190 60 {lab=VDD}
C {devices/vdd.sym} 11190 60 0 0 {name=s1121 lab=VDD}
N 73360 30 73360 10 {lab=VDD}
C {devices/vdd.sym} 73360 10 0 0 {name=s1122 lab=VDD}
N 73360 60 73390 60 {lab=VDD}
C {devices/vdd.sym} 73390 60 0 0 {name=s1123 lab=VDD}
N 73360 210 73390 210 {lab=VDD}
C {devices/vdd.sym} 73390 210 0 0 {name=s1124 lab=VDD}
N 73760 210 73790 210 {lab=VDD}
C {devices/vdd.sym} 73790 210 0 0 {name=s1125 lab=VDD}
N 73560 30 73560 10 {lab=VDD}
C {devices/vdd.sym} 73560 10 0 0 {name=s1126 lab=VDD}
N 73560 60 73590 60 {lab=VDD}
C {devices/vdd.sym} 73590 60 0 0 {name=s1127 lab=VDD}
N 73760 30 73760 10 {lab=VDD}
C {devices/vdd.sym} 73760 10 0 0 {name=s1128 lab=VDD}
N 73760 60 73790 60 {lab=VDD}
C {devices/vdd.sym} 73790 60 0 0 {name=s1129 lab=VDD}
N 74120 30 74120 10 {lab=VDD}
C {devices/vdd.sym} 74120 10 0 0 {name=s1130 lab=VDD}
N 74120 60 74150 60 {lab=VDD}
C {devices/vdd.sym} 74150 60 0 0 {name=s1131 lab=VDD}
N 74120 210 74150 210 {lab=VDD}
C {devices/vdd.sym} 74150 210 0 0 {name=s1132 lab=VDD}
N 74320 210 74350 210 {lab=VDD}
C {devices/vdd.sym} 74350 210 0 0 {name=s1133 lab=VDD}
N 74320 30 74320 10 {lab=VDD}
C {devices/vdd.sym} 74320 10 0 0 {name=s1134 lab=VDD}
N 74320 60 74350 60 {lab=VDD}
C {devices/vdd.sym} 74350 60 0 0 {name=s1135 lab=VDD}
N 70200 30 70200 10 {lab=VDD}
C {devices/vdd.sym} 70200 10 0 0 {name=s1136 lab=VDD}
N 70200 60 70230 60 {lab=VDD}
C {devices/vdd.sym} 70230 60 0 0 {name=s1137 lab=VDD}
N 70400 30 70400 10 {lab=VDD}
C {devices/vdd.sym} 70400 10 0 0 {name=s1138 lab=VDD}
N 70400 60 70430 60 {lab=VDD}
C {devices/vdd.sym} 70430 60 0 0 {name=s1139 lab=VDD}
N 70760 30 70760 10 {lab=VDD}
C {devices/vdd.sym} 70760 10 0 0 {name=s1140 lab=VDD}
N 70760 60 70790 60 {lab=VDD}
C {devices/vdd.sym} 70790 60 0 0 {name=s1141 lab=VDD}
N 5400 1400 5400 1420 {lab=0}
C {devices/gnd.sym} 5400 1420 0 0 {name=s1142 lab=0}
N 5400 1370 5430 1370 {lab=0}
C {devices/gnd.sym} 5430 1370 0 0 {name=s1143 lab=0}
N 11520 1400 11520 1420 {lab=0}
C {devices/gnd.sym} 11520 1420 0 0 {name=s1144 lab=0}
N 11520 1370 11550 1370 {lab=0}
C {devices/gnd.sym} 11550 1370 0 0 {name=s1145 lab=0}
N 78040 1400 78040 1420 {lab=0}
C {devices/gnd.sym} 78040 1420 0 0 {name=s1146 lab=0}
N 78040 1370 78070 1370 {lab=0}
C {devices/gnd.sym} 78070 1370 0 0 {name=s1147 lab=0}
N 78040 1220 78070 1220 {lab=0}
C {devices/gnd.sym} 78070 1220 0 0 {name=s1148 lab=0}
N 78240 1070 78270 1070 {lab=0}
C {devices/gnd.sym} 78270 1070 0 0 {name=s1149 lab=0}
N 78240 1220 78270 1220 {lab=0}
C {devices/gnd.sym} 78270 1220 0 0 {name=s1150 lab=0}
N 78240 1400 78240 1420 {lab=0}
C {devices/gnd.sym} 78240 1420 0 0 {name=s1151 lab=0}
N 78240 1370 78270 1370 {lab=0}
C {devices/gnd.sym} 78270 1370 0 0 {name=s1152 lab=0}
N 78800 1400 78800 1420 {lab=0}
C {devices/gnd.sym} 78800 1420 0 0 {name=s1153 lab=0}
N 78800 1370 78830 1370 {lab=0}
C {devices/gnd.sym} 78830 1370 0 0 {name=s1154 lab=0}
N 78800 1220 78830 1220 {lab=0}
C {devices/gnd.sym} 78830 1220 0 0 {name=s1155 lab=0}
N 79000 1220 79030 1220 {lab=0}
C {devices/gnd.sym} 79030 1220 0 0 {name=s1156 lab=0}
N 79000 1400 79000 1420 {lab=0}
C {devices/gnd.sym} 79000 1420 0 0 {name=s1157 lab=0}
N 79000 1370 79030 1370 {lab=0}
C {devices/gnd.sym} 79030 1370 0 0 {name=s1158 lab=0}
N 74680 1400 74680 1420 {lab=0}
C {devices/gnd.sym} 74680 1420 0 0 {name=s1159 lab=0}
N 74680 1370 74710 1370 {lab=0}
C {devices/gnd.sym} 74710 1370 0 0 {name=s1160 lab=0}
N 74680 1220 74710 1220 {lab=0}
C {devices/gnd.sym} 74710 1220 0 0 {name=s1161 lab=0}
N 75240 1400 75240 1420 {lab=0}
C {devices/gnd.sym} 75240 1420 0 0 {name=s1162 lab=0}
N 75240 1370 75270 1370 {lab=0}
C {devices/gnd.sym} 75270 1370 0 0 {name=s1163 lab=0}
N 5400 30 5400 10 {lab=VDD}
C {devices/vdd.sym} 5400 10 0 0 {name=s1164 lab=VDD}
N 5400 60 5430 60 {lab=VDD}
C {devices/vdd.sym} 5430 60 0 0 {name=s1165 lab=VDD}
N 11520 30 11520 10 {lab=VDD}
C {devices/vdd.sym} 11520 10 0 0 {name=s1166 lab=VDD}
N 11520 60 11550 60 {lab=VDD}
C {devices/vdd.sym} 11550 60 0 0 {name=s1167 lab=VDD}
N 78040 30 78040 10 {lab=VDD}
C {devices/vdd.sym} 78040 10 0 0 {name=s1168 lab=VDD}
N 78040 60 78070 60 {lab=VDD}
C {devices/vdd.sym} 78070 60 0 0 {name=s1169 lab=VDD}
N 78040 210 78070 210 {lab=VDD}
C {devices/vdd.sym} 78070 210 0 0 {name=s1170 lab=VDD}
N 78440 210 78470 210 {lab=VDD}
C {devices/vdd.sym} 78470 210 0 0 {name=s1171 lab=VDD}
N 78240 30 78240 10 {lab=VDD}
C {devices/vdd.sym} 78240 10 0 0 {name=s1172 lab=VDD}
N 78240 60 78270 60 {lab=VDD}
C {devices/vdd.sym} 78270 60 0 0 {name=s1173 lab=VDD}
N 78440 30 78440 10 {lab=VDD}
C {devices/vdd.sym} 78440 10 0 0 {name=s1174 lab=VDD}
N 78440 60 78470 60 {lab=VDD}
C {devices/vdd.sym} 78470 60 0 0 {name=s1175 lab=VDD}
N 78800 30 78800 10 {lab=VDD}
C {devices/vdd.sym} 78800 10 0 0 {name=s1176 lab=VDD}
N 78800 60 78830 60 {lab=VDD}
C {devices/vdd.sym} 78830 60 0 0 {name=s1177 lab=VDD}
N 78800 210 78830 210 {lab=VDD}
C {devices/vdd.sym} 78830 210 0 0 {name=s1178 lab=VDD}
N 79000 210 79030 210 {lab=VDD}
C {devices/vdd.sym} 79030 210 0 0 {name=s1179 lab=VDD}
N 79000 30 79000 10 {lab=VDD}
C {devices/vdd.sym} 79000 10 0 0 {name=s1180 lab=VDD}
N 79000 60 79030 60 {lab=VDD}
C {devices/vdd.sym} 79030 60 0 0 {name=s1181 lab=VDD}
N 74680 30 74680 10 {lab=VDD}
C {devices/vdd.sym} 74680 10 0 0 {name=s1182 lab=VDD}
N 74680 60 74710 60 {lab=VDD}
C {devices/vdd.sym} 74710 60 0 0 {name=s1183 lab=VDD}
N 74880 30 74880 10 {lab=VDD}
C {devices/vdd.sym} 74880 10 0 0 {name=s1184 lab=VDD}
N 74880 60 74910 60 {lab=VDD}
C {devices/vdd.sym} 74910 60 0 0 {name=s1185 lab=VDD}
N 75240 30 75240 10 {lab=VDD}
C {devices/vdd.sym} 75240 10 0 0 {name=s1186 lab=VDD}
N 75240 60 75270 60 {lab=VDD}
C {devices/vdd.sym} 75270 60 0 0 {name=s1187 lab=VDD}
N 5760 1400 5760 1420 {lab=0}
C {devices/gnd.sym} 5760 1420 0 0 {name=s1188 lab=0}
N 5760 1370 5790 1370 {lab=0}
C {devices/gnd.sym} 5790 1370 0 0 {name=s1189 lab=0}
N 11880 1400 11880 1420 {lab=0}
C {devices/gnd.sym} 11880 1420 0 0 {name=s1190 lab=0}
N 11880 1370 11910 1370 {lab=0}
C {devices/gnd.sym} 11910 1370 0 0 {name=s1191 lab=0}
N 82520 1400 82520 1420 {lab=0}
C {devices/gnd.sym} 82520 1420 0 0 {name=s1192 lab=0}
N 82520 1370 82550 1370 {lab=0}
C {devices/gnd.sym} 82550 1370 0 0 {name=s1193 lab=0}
N 82520 1220 82550 1220 {lab=0}
C {devices/gnd.sym} 82550 1220 0 0 {name=s1194 lab=0}
N 82720 1070 82750 1070 {lab=0}
C {devices/gnd.sym} 82750 1070 0 0 {name=s1195 lab=0}
N 82720 1220 82750 1220 {lab=0}
C {devices/gnd.sym} 82750 1220 0 0 {name=s1196 lab=0}
N 82720 1400 82720 1420 {lab=0}
C {devices/gnd.sym} 82720 1420 0 0 {name=s1197 lab=0}
N 82720 1370 82750 1370 {lab=0}
C {devices/gnd.sym} 82750 1370 0 0 {name=s1198 lab=0}
N 83280 1400 83280 1420 {lab=0}
C {devices/gnd.sym} 83280 1420 0 0 {name=s1199 lab=0}
N 83280 1370 83310 1370 {lab=0}
C {devices/gnd.sym} 83310 1370 0 0 {name=s1200 lab=0}
N 83280 1220 83310 1220 {lab=0}
C {devices/gnd.sym} 83310 1220 0 0 {name=s1201 lab=0}
N 83480 1220 83510 1220 {lab=0}
C {devices/gnd.sym} 83510 1220 0 0 {name=s1202 lab=0}
N 83480 1400 83480 1420 {lab=0}
C {devices/gnd.sym} 83480 1420 0 0 {name=s1203 lab=0}
N 83480 1370 83510 1370 {lab=0}
C {devices/gnd.sym} 83510 1370 0 0 {name=s1204 lab=0}
N 79360 1400 79360 1420 {lab=0}
C {devices/gnd.sym} 79360 1420 0 0 {name=s1205 lab=0}
N 79360 1370 79390 1370 {lab=0}
C {devices/gnd.sym} 79390 1370 0 0 {name=s1206 lab=0}
N 79360 1220 79390 1220 {lab=0}
C {devices/gnd.sym} 79390 1220 0 0 {name=s1207 lab=0}
N 79920 1400 79920 1420 {lab=0}
C {devices/gnd.sym} 79920 1420 0 0 {name=s1208 lab=0}
N 79920 1370 79950 1370 {lab=0}
C {devices/gnd.sym} 79950 1370 0 0 {name=s1209 lab=0}
N 5760 30 5760 10 {lab=VDD}
C {devices/vdd.sym} 5760 10 0 0 {name=s1210 lab=VDD}
N 5760 60 5790 60 {lab=VDD}
C {devices/vdd.sym} 5790 60 0 0 {name=s1211 lab=VDD}
N 11880 30 11880 10 {lab=VDD}
C {devices/vdd.sym} 11880 10 0 0 {name=s1212 lab=VDD}
N 11880 60 11910 60 {lab=VDD}
C {devices/vdd.sym} 11910 60 0 0 {name=s1213 lab=VDD}
N 82520 30 82520 10 {lab=VDD}
C {devices/vdd.sym} 82520 10 0 0 {name=s1214 lab=VDD}
N 82520 60 82550 60 {lab=VDD}
C {devices/vdd.sym} 82550 60 0 0 {name=s1215 lab=VDD}
N 82520 210 82550 210 {lab=VDD}
C {devices/vdd.sym} 82550 210 0 0 {name=s1216 lab=VDD}
N 82920 210 82950 210 {lab=VDD}
C {devices/vdd.sym} 82950 210 0 0 {name=s1217 lab=VDD}
N 82720 30 82720 10 {lab=VDD}
C {devices/vdd.sym} 82720 10 0 0 {name=s1218 lab=VDD}
N 82720 60 82750 60 {lab=VDD}
C {devices/vdd.sym} 82750 60 0 0 {name=s1219 lab=VDD}
N 82920 30 82920 10 {lab=VDD}
C {devices/vdd.sym} 82920 10 0 0 {name=s1220 lab=VDD}
N 82920 60 82950 60 {lab=VDD}
C {devices/vdd.sym} 82950 60 0 0 {name=s1221 lab=VDD}
N 83280 30 83280 10 {lab=VDD}
C {devices/vdd.sym} 83280 10 0 0 {name=s1222 lab=VDD}
N 83280 60 83310 60 {lab=VDD}
C {devices/vdd.sym} 83310 60 0 0 {name=s1223 lab=VDD}
N 83280 210 83310 210 {lab=VDD}
C {devices/vdd.sym} 83310 210 0 0 {name=s1224 lab=VDD}
N 83480 210 83510 210 {lab=VDD}
C {devices/vdd.sym} 83510 210 0 0 {name=s1225 lab=VDD}
N 83480 30 83480 10 {lab=VDD}
C {devices/vdd.sym} 83480 10 0 0 {name=s1226 lab=VDD}
N 83480 60 83510 60 {lab=VDD}
C {devices/vdd.sym} 83510 60 0 0 {name=s1227 lab=VDD}
N 79360 30 79360 10 {lab=VDD}
C {devices/vdd.sym} 79360 10 0 0 {name=s1228 lab=VDD}
N 79360 60 79390 60 {lab=VDD}
C {devices/vdd.sym} 79390 60 0 0 {name=s1229 lab=VDD}
N 79560 30 79560 10 {lab=VDD}
C {devices/vdd.sym} 79560 10 0 0 {name=s1230 lab=VDD}
N 79560 60 79590 60 {lab=VDD}
C {devices/vdd.sym} 79590 60 0 0 {name=s1231 lab=VDD}
N 79920 30 79920 10 {lab=VDD}
C {devices/vdd.sym} 79920 10 0 0 {name=s1232 lab=VDD}
N 79920 60 79950 60 {lab=VDD}
C {devices/vdd.sym} 79950 60 0 0 {name=s1233 lab=VDD}
N 6120 1400 6120 1420 {lab=0}
C {devices/gnd.sym} 6120 1420 0 0 {name=s1234 lab=0}
N 6120 1370 6150 1370 {lab=0}
C {devices/gnd.sym} 6150 1370 0 0 {name=s1235 lab=0}
N 12240 1400 12240 1420 {lab=0}
C {devices/gnd.sym} 12240 1420 0 0 {name=s1236 lab=0}
N 12240 1370 12270 1370 {lab=0}
C {devices/gnd.sym} 12270 1370 0 0 {name=s1237 lab=0}
N 83840 1400 83840 1420 {lab=0}
C {devices/gnd.sym} 83840 1420 0 0 {name=s1238 lab=0}
N 83840 1370 83870 1370 {lab=0}
C {devices/gnd.sym} 83870 1370 0 0 {name=s1239 lab=0}
N 83840 1220 83870 1220 {lab=0}
C {devices/gnd.sym} 83870 1220 0 0 {name=s1240 lab=0}
N 84040 1070 84070 1070 {lab=0}
C {devices/gnd.sym} 84070 1070 0 0 {name=s1241 lab=0}
N 84040 1220 84070 1220 {lab=0}
C {devices/gnd.sym} 84070 1220 0 0 {name=s1242 lab=0}
N 84040 1400 84040 1420 {lab=0}
C {devices/gnd.sym} 84040 1420 0 0 {name=s1243 lab=0}
N 84040 1370 84070 1370 {lab=0}
C {devices/gnd.sym} 84070 1370 0 0 {name=s1244 lab=0}
N 85160 1400 85160 1420 {lab=0}
C {devices/gnd.sym} 85160 1420 0 0 {name=s1245 lab=0}
N 85160 1370 85190 1370 {lab=0}
C {devices/gnd.sym} 85190 1370 0 0 {name=s1246 lab=0}
N 85160 1220 85190 1220 {lab=0}
C {devices/gnd.sym} 85190 1220 0 0 {name=s1247 lab=0}
N 85360 1220 85390 1220 {lab=0}
C {devices/gnd.sym} 85390 1220 0 0 {name=s1248 lab=0}
N 85360 1400 85360 1420 {lab=0}
C {devices/gnd.sym} 85360 1420 0 0 {name=s1249 lab=0}
N 85360 1370 85390 1370 {lab=0}
C {devices/gnd.sym} 85390 1370 0 0 {name=s1250 lab=0}
N 84600 1400 84600 1420 {lab=0}
C {devices/gnd.sym} 84600 1420 0 0 {name=s1251 lab=0}
N 84600 1370 84630 1370 {lab=0}
C {devices/gnd.sym} 84630 1370 0 0 {name=s1252 lab=0}
N 84600 1220 84630 1220 {lab=0}
C {devices/gnd.sym} 84630 1220 0 0 {name=s1253 lab=0}
N 85720 1400 85720 1420 {lab=0}
C {devices/gnd.sym} 85720 1420 0 0 {name=s1254 lab=0}
N 85720 1370 85750 1370 {lab=0}
C {devices/gnd.sym} 85750 1370 0 0 {name=s1255 lab=0}
N 6120 30 6120 10 {lab=VDD}
C {devices/vdd.sym} 6120 10 0 0 {name=s1256 lab=VDD}
N 6120 60 6150 60 {lab=VDD}
C {devices/vdd.sym} 6150 60 0 0 {name=s1257 lab=VDD}
N 12240 30 12240 10 {lab=VDD}
C {devices/vdd.sym} 12240 10 0 0 {name=s1258 lab=VDD}
N 12240 60 12270 60 {lab=VDD}
C {devices/vdd.sym} 12270 60 0 0 {name=s1259 lab=VDD}
N 83840 30 83840 10 {lab=VDD}
C {devices/vdd.sym} 83840 10 0 0 {name=s1260 lab=VDD}
N 83840 60 83870 60 {lab=VDD}
C {devices/vdd.sym} 83870 60 0 0 {name=s1261 lab=VDD}
N 83840 210 83870 210 {lab=VDD}
C {devices/vdd.sym} 83870 210 0 0 {name=s1262 lab=VDD}
N 84240 210 84270 210 {lab=VDD}
C {devices/vdd.sym} 84270 210 0 0 {name=s1263 lab=VDD}
N 84040 30 84040 10 {lab=VDD}
C {devices/vdd.sym} 84040 10 0 0 {name=s1264 lab=VDD}
N 84040 60 84070 60 {lab=VDD}
C {devices/vdd.sym} 84070 60 0 0 {name=s1265 lab=VDD}
N 84240 30 84240 10 {lab=VDD}
C {devices/vdd.sym} 84240 10 0 0 {name=s1266 lab=VDD}
N 84240 60 84270 60 {lab=VDD}
C {devices/vdd.sym} 84270 60 0 0 {name=s1267 lab=VDD}
N 85160 30 85160 10 {lab=VDD}
C {devices/vdd.sym} 85160 10 0 0 {name=s1268 lab=VDD}
N 85160 60 85190 60 {lab=VDD}
C {devices/vdd.sym} 85190 60 0 0 {name=s1269 lab=VDD}
N 85160 210 85190 210 {lab=VDD}
C {devices/vdd.sym} 85190 210 0 0 {name=s1270 lab=VDD}
N 85360 210 85390 210 {lab=VDD}
C {devices/vdd.sym} 85390 210 0 0 {name=s1271 lab=VDD}
N 85360 30 85360 10 {lab=VDD}
C {devices/vdd.sym} 85360 10 0 0 {name=s1272 lab=VDD}
N 85360 60 85390 60 {lab=VDD}
C {devices/vdd.sym} 85390 60 0 0 {name=s1273 lab=VDD}
N 84600 30 84600 10 {lab=VDD}
C {devices/vdd.sym} 84600 10 0 0 {name=s1274 lab=VDD}
N 84600 60 84630 60 {lab=VDD}
C {devices/vdd.sym} 84630 60 0 0 {name=s1275 lab=VDD}
N 84800 30 84800 10 {lab=VDD}
C {devices/vdd.sym} 84800 10 0 0 {name=s1276 lab=VDD}
N 84800 60 84830 60 {lab=VDD}
C {devices/vdd.sym} 84830 60 0 0 {name=s1277 lab=VDD}
N 85720 30 85720 10 {lab=VDD}
C {devices/vdd.sym} 85720 10 0 0 {name=s1278 lab=VDD}
N 85720 60 85750 60 {lab=VDD}
C {devices/vdd.sym} 85750 60 0 0 {name=s1279 lab=VDD}
N 25880 1370 25870 1370 {lab=rst_n}
N 25870 1370 25870 1330 {lab=rst_n}
N 25870 1330 25960 1330 {lab=rst_n}
N 25960 1330 25960 1370 {lab=rst_n}
N 25960 1370 26070 1370 {lab=rst_n}
N 26070 1370 26070 990 {lab=rst_n}
N 26070 1370 26430 1370 {lab=rst_n}
N 26430 1370 26440 1370 {lab=rst_n}
N 26430 1370 26430 1330 {lab=rst_n}
N 26070 990 -60 990 {lab=rst_n}
N 26070 990 26070 100 {lab=rst_n}
N 26070 100 26160 100 {lab=rst_n}
N 26070 100 26070 60 {lab=rst_n}
N 26070 60 26080 60 {lab=rst_n}
N 26160 100 26160 60 {lab=rst_n}
N 26160 60 26440 60 {lab=rst_n}
N 26430 1330 28960 1330 {lab=rst_n}
N 28960 1330 28960 1370 {lab=rst_n}
N 28960 1370 29070 1370 {lab=rst_n}
N 29070 1370 29080 1370 {lab=rst_n}
N 29070 1370 29070 1330 {lab=rst_n}
N 29070 1330 29160 1330 {lab=rst_n}
N 29160 1330 29160 1370 {lab=rst_n}
N 29160 1370 29270 1370 {lab=rst_n}
N 29270 1370 29270 100 {lab=rst_n}
N 29270 1370 29630 1370 {lab=rst_n}
N 29630 1370 29640 1370 {lab=rst_n}
N 29630 1370 29630 1330 {lab=rst_n}
N 29270 100 29360 100 {lab=rst_n}
N 29270 100 29270 60 {lab=rst_n}
N 29270 60 29280 60 {lab=rst_n}
N 29360 100 29360 60 {lab=rst_n}
N 29360 60 29640 60 {lab=rst_n}
N 29630 1330 34200 1330 {lab=rst_n}
N 34200 1330 34200 1370 {lab=rst_n}
N 34200 1370 34310 1370 {lab=rst_n}
N 34310 1370 34320 1370 {lab=rst_n}
N 34310 1370 34310 1330 {lab=rst_n}
N 34310 1330 34400 1330 {lab=rst_n}
N 34400 1330 34400 1370 {lab=rst_n}
N 34400 1370 34510 1370 {lab=rst_n}
N 34510 1370 34870 1370 {lab=rst_n}
N 34510 1370 34510 100 {lab=rst_n}
N 34870 1370 34880 1370 {lab=rst_n}
N 34870 1370 34870 1330 {lab=rst_n}
N 34510 100 34600 100 {lab=rst_n}
N 34510 100 34510 60 {lab=rst_n}
N 34510 60 34520 60 {lab=rst_n}
N 34600 100 34600 60 {lab=rst_n}
N 34600 60 34880 60 {lab=rst_n}
N 34870 1330 36800 1330 {lab=rst_n}
N 36800 1330 36800 1370 {lab=rst_n}
N 36800 1370 36910 1370 {lab=rst_n}
N 36910 1370 36920 1370 {lab=rst_n}
N 36910 1370 36910 1330 {lab=rst_n}
N 36910 1330 37000 1330 {lab=rst_n}
N 37000 1330 37000 1370 {lab=rst_n}
N 37000 1370 37110 1370 {lab=rst_n}
N 37110 1370 37470 1370 {lab=rst_n}
N 37110 1370 37110 100 {lab=rst_n}
N 37470 1370 37470 1330 {lab=rst_n}
N 37470 1370 37480 1370 {lab=rst_n}
N 37110 100 37110 60 {lab=rst_n}
N 37110 100 37200 100 {lab=rst_n}
N 37110 60 37120 60 {lab=rst_n}
N 37200 100 37200 60 {lab=rst_n}
N 37200 60 37480 60 {lab=rst_n}
N 37470 1330 39040 1330 {lab=rst_n}
N 39040 1330 39040 1370 {lab=rst_n}
N 39040 1370 39510 1370 {lab=rst_n}
N 39510 1370 39520 1370 {lab=rst_n}
N 39510 1370 39510 1330 {lab=rst_n}
N 39510 1330 41080 1330 {lab=rst_n}
N 39510 1330 39510 60 {lab=rst_n}
N 39510 60 39520 60 {lab=rst_n}
N 41080 1330 41080 1370 {lab=rst_n}
N 41080 1370 41190 1370 {lab=rst_n}
N 41190 1370 41190 1330 {lab=rst_n}
N 41190 1370 41200 1370 {lab=rst_n}
N 41190 1330 41390 1330 {lab=rst_n}
N 41390 1330 42040 1330 {lab=rst_n}
N 41390 1330 41390 100 {lab=rst_n}
N 42040 1330 42040 1370 {lab=rst_n}
N 42040 1370 42310 1370 {lab=rst_n}
N 42310 1370 42310 1330 {lab=rst_n}
N 42310 1370 42320 1370 {lab=rst_n}
N 41390 100 41390 60 {lab=rst_n}
N 41390 100 42040 100 {lab=rst_n}
N 41390 60 41400 60 {lab=rst_n}
N 42040 100 42040 60 {lab=rst_n}
N 42040 60 42320 60 {lab=rst_n}
N 42310 1330 45560 1330 {lab=rst_n}
N 45560 1330 45560 1370 {lab=rst_n}
N 45560 1370 45670 1370 {lab=rst_n}
N 45670 1370 45670 1330 {lab=rst_n}
N 45670 1370 45680 1370 {lab=rst_n}
N 45670 1330 45870 1330 {lab=rst_n}
N 45870 1330 45870 60 {lab=rst_n}
N 45870 1330 46880 1330 {lab=rst_n}
N 46880 1330 46880 1370 {lab=rst_n}
N 46880 1370 46990 1370 {lab=rst_n}
N 46990 1370 47000 1370 {lab=rst_n}
N 46990 1370 46990 1330 {lab=rst_n}
N 45870 60 45880 60 {lab=rst_n}
N 46990 1330 47080 1330 {lab=rst_n}
N 47080 1330 47080 1370 {lab=rst_n}
N 47080 1370 47190 1370 {lab=rst_n}
N 47190 1370 47190 100 {lab=rst_n}
N 47190 1370 47550 1370 {lab=rst_n}
N 47550 1370 47560 1370 {lab=rst_n}
N 47550 1370 47550 1330 {lab=rst_n}
N 47190 100 47280 100 {lab=rst_n}
N 47190 100 47190 60 {lab=rst_n}
N 47190 60 47200 60 {lab=rst_n}
N 47280 100 47280 60 {lab=rst_n}
N 47280 60 47560 60 {lab=rst_n}
N 47550 1330 51200 1330 {lab=rst_n}
N 51200 1330 51200 1370 {lab=rst_n}
N 51200 1370 51310 1370 {lab=rst_n}
N 51310 1370 51310 1330 {lab=rst_n}
N 51310 1370 51320 1370 {lab=rst_n}
N 51310 1330 51400 1330 {lab=rst_n}
N 51400 1330 51400 1370 {lab=rst_n}
N 51400 1370 51510 1370 {lab=rst_n}
N 51510 1370 51510 100 {lab=rst_n}
N 51510 1370 51870 1370 {lab=rst_n}
N 51870 1370 51880 1370 {lab=rst_n}
N 51870 1370 51870 1330 {lab=rst_n}
N 51510 100 51600 100 {lab=rst_n}
N 51510 100 51510 60 {lab=rst_n}
N 51510 60 51520 60 {lab=rst_n}
N 51600 100 51600 60 {lab=rst_n}
N 51600 60 51880 60 {lab=rst_n}
N 51870 1330 54200 1330 {lab=rst_n}
N 54200 1330 54200 1370 {lab=rst_n}
N 54200 1370 54470 1370 {lab=rst_n}
N 54470 1370 54470 1330 {lab=rst_n}
N 54470 1370 54480 1370 {lab=rst_n}
N 54470 1330 56760 1330 {lab=rst_n}
N 54470 1330 54470 60 {lab=rst_n}
N 54470 60 54480 60 {lab=rst_n}
N 56760 1330 56760 1370 {lab=rst_n}
N 56760 1370 56870 1370 {lab=rst_n}
N 56870 1370 56880 1370 {lab=rst_n}
N 56870 1370 56870 1330 {lab=rst_n}
N 56870 1330 57070 1330 {lab=rst_n}
N 57070 1330 58080 1330 {lab=rst_n}
N 57070 1330 57070 60 {lab=rst_n}
N 58080 1330 58080 1370 {lab=rst_n}
N 58080 1370 58190 1370 {lab=rst_n}
N 58190 1370 58200 1370 {lab=rst_n}
N 58190 1370 58190 1330 {lab=rst_n}
N 57070 60 57080 60 {lab=rst_n}
N 58190 1330 58280 1330 {lab=rst_n}
N 58280 1330 58280 1370 {lab=rst_n}
N 58280 1370 58390 1370 {lab=rst_n}
N 58390 1370 58750 1370 {lab=rst_n}
N 58390 1370 58390 100 {lab=rst_n}
N 58750 1370 58750 1330 {lab=rst_n}
N 58750 1370 58760 1370 {lab=rst_n}
N 58390 100 58480 100 {lab=rst_n}
N 58390 100 58390 60 {lab=rst_n}
N 58390 60 58400 60 {lab=rst_n}
N 58480 100 58480 60 {lab=rst_n}
N 58480 60 58760 60 {lab=rst_n}
N 58750 1330 60880 1330 {lab=rst_n}
N 60880 1330 60880 1370 {lab=rst_n}
N 60880 1370 61350 1370 {lab=rst_n}
N 61350 1370 61360 1370 {lab=rst_n}
N 61350 1370 61350 1330 {lab=rst_n}
N 61350 1330 61350 60 {lab=rst_n}
N 61350 1330 64800 1330 {lab=rst_n}
N 61350 60 61360 60 {lab=rst_n}
N 64800 1330 64800 1370 {lab=rst_n}
N 64800 1370 64910 1370 {lab=rst_n}
N 64910 1370 64910 1330 {lab=rst_n}
N 64910 1370 64920 1370 {lab=rst_n}
N 64910 1330 65110 1330 {lab=rst_n}
N 65110 1330 65760 1330 {lab=rst_n}
N 65110 1330 65110 100 {lab=rst_n}
N 65760 1330 65760 1370 {lab=rst_n}
N 65760 1370 66030 1370 {lab=rst_n}
N 66030 1370 66030 1330 {lab=rst_n}
N 66030 1370 66040 1370 {lab=rst_n}
N 65110 100 65760 100 {lab=rst_n}
N 65110 100 65110 60 {lab=rst_n}
N 65110 60 65120 60 {lab=rst_n}
N 65760 100 65760 60 {lab=rst_n}
N 65760 60 66040 60 {lab=rst_n}
N 66030 1330 68920 1330 {lab=rst_n}
N 68920 1330 68920 1370 {lab=rst_n}
N 68920 1370 69030 1370 {lab=rst_n}
N 69030 1370 69040 1370 {lab=rst_n}
N 69030 1370 69030 1330 {lab=rst_n}
N 69030 1330 69230 1330 {lab=rst_n}
N 69230 1330 69880 1330 {lab=rst_n}
N 69230 1330 69230 100 {lab=rst_n}
N 69880 1330 69880 1370 {lab=rst_n}
N 69880 1370 70150 1370 {lab=rst_n}
N 70150 1370 70160 1370 {lab=rst_n}
N 70150 1370 70150 1330 {lab=rst_n}
N 69230 100 69880 100 {lab=rst_n}
N 69230 100 69230 60 {lab=rst_n}
N 69230 60 69240 60 {lab=rst_n}
N 69880 100 69880 60 {lab=rst_n}
N 69880 60 70160 60 {lab=rst_n}
N 70150 1330 73400 1330 {lab=rst_n}
N 73400 1330 73400 1370 {lab=rst_n}
N 73400 1370 73510 1370 {lab=rst_n}
N 73510 1370 73520 1370 {lab=rst_n}
N 73510 1370 73510 1330 {lab=rst_n}
N 73510 1330 73710 1330 {lab=rst_n}
N 73710 1330 74360 1330 {lab=rst_n}
N 73710 1330 73710 100 {lab=rst_n}
N 74360 1330 74360 1370 {lab=rst_n}
N 74360 1370 74630 1370 {lab=rst_n}
N 74630 1370 74630 1330 {lab=rst_n}
N 74630 1370 74640 1370 {lab=rst_n}
N 73710 100 74360 100 {lab=rst_n}
N 73710 100 73710 60 {lab=rst_n}
N 73710 60 73720 60 {lab=rst_n}
N 74360 100 74360 60 {lab=rst_n}
N 74360 60 74640 60 {lab=rst_n}
N 74630 1330 78080 1330 {lab=rst_n}
N 78080 1330 78080 1370 {lab=rst_n}
N 78080 1370 78190 1370 {lab=rst_n}
N 78190 1370 78190 1330 {lab=rst_n}
N 78190 1370 78200 1370 {lab=rst_n}
N 78190 1330 78390 1330 {lab=rst_n}
N 78390 1330 79040 1330 {lab=rst_n}
N 78390 1330 78390 100 {lab=rst_n}
N 79040 1330 79040 1370 {lab=rst_n}
N 79040 1370 79310 1370 {lab=rst_n}
N 79310 1370 79310 1330 {lab=rst_n}
N 79310 1370 79320 1370 {lab=rst_n}
N 78390 100 78390 60 {lab=rst_n}
N 78390 100 79040 100 {lab=rst_n}
N 78390 60 78400 60 {lab=rst_n}
N 79040 100 79040 60 {lab=rst_n}
N 79040 60 79320 60 {lab=rst_n}
N 79310 1330 82560 1330 {lab=rst_n}
N 82560 1330 82560 1370 {lab=rst_n}
N 82560 1370 82670 1370 {lab=rst_n}
N 82670 1370 82670 1330 {lab=rst_n}
N 82670 1370 82680 1370 {lab=rst_n}
N 82670 1330 82870 1330 {lab=rst_n}
N 82870 1330 83880 1330 {lab=rst_n}
N 82870 1330 82870 60 {lab=rst_n}
N 83880 1330 83880 1370 {lab=rst_n}
N 83880 1370 83990 1370 {lab=rst_n}
N 83990 1370 84000 1370 {lab=rst_n}
N 83990 1370 83990 1330 {lab=rst_n}
N 82870 60 82880 60 {lab=rst_n}
N 83990 1330 84080 1330 {lab=rst_n}
N 84080 1330 84080 1370 {lab=rst_n}
N 84080 1370 84190 1370 {lab=rst_n}
N 84190 1370 84190 100 {lab=rst_n}
N 84190 1370 84560 1370 {lab=rst_n}
N 84190 100 84280 100 {lab=rst_n}
N 84190 100 84190 60 {lab=rst_n}
N 84190 60 84200 60 {lab=rst_n}
N 84280 100 84280 60 {lab=rst_n}
N 84280 60 84560 60 {lab=rst_n}
N 680 1370 670 1370 {lab=clk}
N 670 1370 670 1330 {lab=clk}
N 670 1330 670 910 {lab=clk}
N 670 1330 760 1330 {lab=clk}
N 760 1330 760 1370 {lab=clk}
N 760 1370 1030 1370 {lab=clk}
N 1030 1370 1040 1370 {lab=clk}
N 1030 1370 1030 1330 {lab=clk}
N 1030 1330 1120 1330 {lab=clk}
N 1120 1330 1120 1370 {lab=clk}
N 1120 1370 1390 1370 {lab=clk}
N 1390 1370 1390 1330 {lab=clk}
N 1390 1370 1400 1370 {lab=clk}
N 1390 1330 1480 1330 {lab=clk}
N 1480 1330 1480 1370 {lab=clk}
N 1480 1370 1750 1370 {lab=clk}
N 1750 1370 1760 1370 {lab=clk}
N 1750 1370 1750 1330 {lab=clk}
N 670 910 -60 910 {lab=clk}
N 670 910 670 100 {lab=clk}
N 670 100 670 60 {lab=clk}
N 670 100 760 100 {lab=clk}
N 670 60 680 60 {lab=clk}
N 1750 1330 1840 1330 {lab=clk}
N 1840 1330 1840 1370 {lab=clk}
N 1840 1370 2110 1370 {lab=clk}
N 2110 1370 2120 1370 {lab=clk}
N 2110 1370 2110 1330 {lab=clk}
N 760 100 760 60 {lab=clk}
N 760 60 1030 60 {lab=clk}
N 1030 60 1030 100 {lab=clk}
N 1030 60 1040 60 {lab=clk}
N 2110 1330 2200 1330 {lab=clk}
N 2200 1330 2200 1370 {lab=clk}
N 2200 1370 2470 1370 {lab=clk}
N 2470 1370 2470 1330 {lab=clk}
N 2470 1370 2480 1370 {lab=clk}
N 1030 100 1120 100 {lab=clk}
N 1120 100 1120 60 {lab=clk}
N 1120 60 1390 60 {lab=clk}
N 1390 60 1400 60 {lab=clk}
N 1390 60 1390 100 {lab=clk}
N 2470 1330 2560 1330 {lab=clk}
N 2560 1330 2560 1370 {lab=clk}
N 2560 1370 2830 1370 {lab=clk}
N 2830 1370 2830 1330 {lab=clk}
N 2830 1370 2840 1370 {lab=clk}
N 1390 100 1480 100 {lab=clk}
N 1480 100 1480 60 {lab=clk}
N 1480 60 1750 60 {lab=clk}
N 1750 60 1750 100 {lab=clk}
N 1750 60 1760 60 {lab=clk}
N 2830 1330 2920 1330 {lab=clk}
N 2920 1330 2920 1370 {lab=clk}
N 2920 1370 3190 1370 {lab=clk}
N 3190 1370 3200 1370 {lab=clk}
N 3190 1370 3190 1330 {lab=clk}
N 1750 100 1840 100 {lab=clk}
N 1840 100 1840 60 {lab=clk}
N 1840 60 2110 60 {lab=clk}
N 2110 60 2120 60 {lab=clk}
N 2110 60 2110 100 {lab=clk}
N 3190 1330 3280 1330 {lab=clk}
N 3280 1330 3280 1370 {lab=clk}
N 3280 1370 3550 1370 {lab=clk}
N 3550 1370 3560 1370 {lab=clk}
N 3550 1370 3550 1330 {lab=clk}
N 2110 100 2200 100 {lab=clk}
N 2200 100 2200 60 {lab=clk}
N 2200 60 2470 60 {lab=clk}
N 2470 60 2480 60 {lab=clk}
N 2470 60 2470 100 {lab=clk}
N 3550 1330 3640 1330 {lab=clk}
N 3640 1330 3640 1370 {lab=clk}
N 3640 1370 3910 1370 {lab=clk}
N 3910 1370 3920 1370 {lab=clk}
N 3910 1370 3910 1330 {lab=clk}
N 2470 100 2560 100 {lab=clk}
N 2560 100 2560 60 {lab=clk}
N 2560 60 2830 60 {lab=clk}
N 2830 60 2830 100 {lab=clk}
N 2830 60 2840 60 {lab=clk}
N 3910 1330 4000 1330 {lab=clk}
N 4000 1330 4000 1370 {lab=clk}
N 4000 1370 4270 1370 {lab=clk}
N 4270 1370 4270 1330 {lab=clk}
N 4270 1370 4280 1370 {lab=clk}
N 2830 100 2920 100 {lab=clk}
N 2920 100 2920 60 {lab=clk}
N 2920 60 3190 60 {lab=clk}
N 3190 60 3190 100 {lab=clk}
N 3190 60 3200 60 {lab=clk}
N 4270 1330 4360 1330 {lab=clk}
N 4360 1330 4360 1370 {lab=clk}
N 4360 1370 4630 1370 {lab=clk}
N 4630 1370 4640 1370 {lab=clk}
N 4630 1370 4630 1330 {lab=clk}
N 3190 100 3280 100 {lab=clk}
N 3280 100 3280 60 {lab=clk}
N 3280 60 3550 60 {lab=clk}
N 3550 60 3560 60 {lab=clk}
N 3550 60 3550 100 {lab=clk}
N 4630 1330 4720 1330 {lab=clk}
N 4720 1330 4720 1370 {lab=clk}
N 4720 1370 4990 1370 {lab=clk}
N 4990 1370 5000 1370 {lab=clk}
N 4990 1370 4990 1330 {lab=clk}
N 3550 100 3640 100 {lab=clk}
N 3640 100 3640 60 {lab=clk}
N 3640 60 3910 60 {lab=clk}
N 3910 60 3910 100 {lab=clk}
N 3910 60 3920 60 {lab=clk}
N 4990 1330 5080 1330 {lab=clk}
N 5080 1330 5080 1370 {lab=clk}
N 5080 1370 5350 1370 {lab=clk}
N 5350 1370 5350 1330 {lab=clk}
N 5350 1370 5360 1370 {lab=clk}
N 3910 100 4000 100 {lab=clk}
N 4000 100 4000 60 {lab=clk}
N 4000 60 4270 60 {lab=clk}
N 4270 60 4280 60 {lab=clk}
N 4270 60 4270 100 {lab=clk}
N 5350 1330 5440 1330 {lab=clk}
N 5440 1330 5440 1370 {lab=clk}
N 5440 1370 5710 1370 {lab=clk}
N 5710 1370 5710 1330 {lab=clk}
N 5710 1370 5720 1370 {lab=clk}
N 4270 100 4360 100 {lab=clk}
N 4360 100 4360 60 {lab=clk}
N 4360 60 4630 60 {lab=clk}
N 4630 60 4630 100 {lab=clk}
N 4630 60 4640 60 {lab=clk}
N 5710 1330 5800 1330 {lab=clk}
N 5800 1330 5800 1370 {lab=clk}
N 5800 1370 6080 1370 {lab=clk}
N 4630 100 4720 100 {lab=clk}
N 4720 100 4720 60 {lab=clk}
N 4720 60 4990 60 {lab=clk}
N 4990 60 5000 60 {lab=clk}
N 4990 60 4990 100 {lab=clk}
N 4990 100 5080 100 {lab=clk}
N 5080 100 5080 60 {lab=clk}
N 5080 60 5350 60 {lab=clk}
N 5350 60 5350 100 {lab=clk}
N 5350 60 5360 60 {lab=clk}
N 5350 100 5440 100 {lab=clk}
N 5440 100 5440 60 {lab=clk}
N 5440 60 5710 60 {lab=clk}
N 5710 60 5710 100 {lab=clk}
N 5710 60 5720 60 {lab=clk}
N 5710 100 5800 100 {lab=clk}
N 5800 100 5800 60 {lab=clk}
N 5800 60 6080 60 {lab=clk}
N 12600 1340 12600 1330 {lab=_048_}
N 12600 1330 12800 1330 {lab=_048_}
N 12600 1330 12600 540 {lab=_048_}
N 12800 1330 12800 1340 {lab=_048_}
N 12800 1330 13000 1330 {lab=_048_}
N 13000 1330 13000 1340 {lab=_048_}
N 13000 1330 13200 1330 {lab=_048_}
N 13200 1330 19240 1330 {lab=_048_}
N 13200 1330 13200 1340 {lab=_048_}
N 19240 1330 19240 1370 {lab=_048_}
N 19240 1370 19510 1370 {lab=_048_}
N 19510 1370 19520 1370 {lab=_048_}
N 19510 1370 19510 1220 {lab=_048_}
N 19510 1220 19510 100 {lab=_048_}
N 19510 1220 20270 1220 {lab=_048_}
N 20270 1220 20270 1430 {lab=_048_}
N 20270 1220 20280 1220 {lab=_048_}
N 19510 100 19510 60 {lab=_048_}
N 19510 100 19600 100 {lab=_048_}
N 19510 60 19520 60 {lab=_048_}
N 19600 100 19600 60 {lab=_048_}
N 19600 60 20280 60 {lab=_048_}
N 20270 1430 40160 1430 {lab=_048_}
N 40160 1430 40160 1370 {lab=_048_}
N 40160 1370 40430 1370 {lab=_048_}
N 40430 1370 40430 1320 {lab=_048_}
N 40430 1370 40440 1370 {lab=_048_}
N 40430 1320 42960 1320 {lab=_048_}
N 40430 1320 40430 210 {lab=_048_}
N 40430 210 40440 210 {lab=_048_}
N 42960 1320 42960 1370 {lab=_048_}
N 42960 1370 43230 1370 {lab=_048_}
N 43230 1370 43230 210 {lab=_048_}
N 43230 1370 43240 1370 {lab=_048_}
N 43230 1370 43230 1430 {lab=_048_}
N 43230 1430 43320 1430 {lab=_048_}
N 43320 1430 43320 1370 {lab=_048_}
N 43320 1370 43990 1370 {lab=_048_}
N 43990 1370 43990 1430 {lab=_048_}
N 43990 1370 44000 1370 {lab=_048_}
N 43230 210 44000 210 {lab=_048_}
N 43230 210 43230 60 {lab=_048_}
N 43230 60 43240 60 {lab=_048_}
N 43990 1430 48760 1430 {lab=_048_}
N 48760 1430 48760 1370 {lab=_048_}
N 48760 1370 49030 1370 {lab=_048_}
N 49030 1370 49030 60 {lab=_048_}
N 49030 1370 49040 1370 {lab=_048_}
N 49030 60 49040 60 {lab=_048_}
N 13520 1370 13510 1370 {lab=_122_}
N 13510 1370 13510 830 {lab=_122_}
N 13510 1370 13510 1430 {lab=_122_}
N 13510 1430 13800 1430 {lab=_122_}
N 13800 1430 13800 1370 {lab=_122_}
N 13800 1370 14070 1370 {lab=_122_}
N 14070 1370 14070 1440 {lab=_122_}
N 14070 1370 14080 1370 {lab=_122_}
N 13510 830 13510 250 {lab=_122_}
N 13510 830 -60 830 {lab=_122_}
N 13510 250 14360 250 {lab=_122_}
N 13510 250 13510 210 {lab=_122_}
N 13510 210 13520 210 {lab=_122_}
N 14360 250 14360 60 {lab=_122_}
N 14360 60 14480 60 {lab=_122_}
N 14070 1440 22240 1440 {lab=_122_}
N 22240 1440 22240 1370 {lab=_122_}
N 22240 1370 22510 1370 {lab=_122_}
N 22510 1370 22510 1320 {lab=_122_}
N 22510 1370 22520 1370 {lab=_122_}
N 22510 1320 22510 60 {lab=_122_}
N 22510 1320 27640 1320 {lab=_122_}
N 22510 60 22520 60 {lab=_122_}
N 27640 1320 27640 1370 {lab=_122_}
N 27640 1370 27910 1370 {lab=_122_}
N 27910 1370 27910 1320 {lab=_122_}
N 27910 1370 27920 1370 {lab=_122_}
N 27910 1320 32720 1320 {lab=_122_}
N 27910 1320 27910 60 {lab=_122_}
N 27910 60 27920 60 {lab=_122_}
N 32720 1320 32720 1370 {lab=_122_}
N 32720 1370 32990 1370 {lab=_122_}
N 32990 1370 32990 1320 {lab=_122_}
N 32990 1370 33000 1370 {lab=_122_}
N 32990 1320 32990 250 {lab=_122_}
N 32990 1320 33280 1320 {lab=_122_}
N 33280 1320 33280 1220 {lab=_122_}
N 33280 1220 33550 1220 {lab=_122_}
N 33550 1220 33550 1440 {lab=_122_}
N 33550 1220 33560 1220 {lab=_122_}
N 32990 250 32990 60 {lab=_122_}
N 32990 250 33640 250 {lab=_122_}
N 32990 60 33000 60 {lab=_122_}
N 33640 250 33640 210 {lab=_122_}
N 33640 210 33760 210 {lab=_122_}
N 33550 1440 76200 1440 {lab=_122_}
N 76200 1440 76200 1220 {lab=_122_}
N 76200 1220 77230 1220 {lab=_122_}
N 77230 1220 77230 1180 {lab=_122_}
N 77230 1220 77240 1220 {lab=_122_}
N 77230 1180 77320 1180 {lab=_122_}
N 77320 1180 77320 60 {lab=_122_}
N 77320 60 77440 60 {lab=_122_}
N 22520 1220 22500 1220 {lab=trials_0}
N 22500 1220 22500 1180 {lab=trials_0}
N 22500 1180 22600 1180 {lab=trials_0}
N 22600 1180 22600 60 {lab=trials_0}
N 22600 1180 22600 1450 {lab=trials_0}
N 22600 60 22720 60 {lab=trials_0}
N 22600 1450 55120 1450 {lab=trials_0}
N 55120 1450 55120 1370 {lab=trials_0}
N 55120 1370 55120 1340 {lab=trials_0}
N 55120 1370 55390 1370 {lab=trials_0}
N 55120 1340 55080 1340 {lab=trials_0}
N 55080 1340 55080 90 {lab=trials_0}
N 55390 1370 55390 1220 {lab=trials_0}
N 55390 1370 55400 1370 {lab=trials_0}
N 55390 1220 55750 1220 {lab=trials_0}
N 55750 1220 55750 1260 {lab=trials_0}
N 55750 1220 55760 1220 {lab=trials_0}
N 55080 90 55120 90 {lab=trials_0}
N 55120 90 55120 60 {lab=trials_0}
N 55120 60 55390 60 {lab=trials_0}
N 55390 60 55390 100 {lab=trials_0}
N 55390 60 55400 60 {lab=trials_0}
N 55390 100 55840 100 {lab=trials_0}
N 55840 100 55840 210 {lab=trials_0}
N 55840 210 55960 210 {lab=trials_0}
N 55750 1260 61440 1260 {lab=trials_0}
N 61440 1260 61440 1220 {lab=trials_0}
N 61440 1220 62270 1220 {lab=trials_0}
N 62270 1220 62270 1070 {lab=trials_0}
N 62270 1220 62280 1220 {lab=trials_0}
N 62270 1070 62470 1070 {lab=trials_0}
N 62470 1070 62830 1070 {lab=trials_0}
N 62470 1070 62470 250 {lab=trials_0}
N 62830 1070 62830 920 {lab=trials_0}
N 62830 1070 62840 1070 {lab=trials_0}
N 62470 250 62470 210 {lab=trials_0}
N 62470 250 63120 250 {lab=trials_0}
N 62470 210 62480 210 {lab=trials_0}
N 63120 250 63120 60 {lab=trials_0}
N 63120 60 63240 60 {lab=trials_0}
N 62830 920 67510 920 {lab=trials_0}
N 67510 920 67510 470 {lab=trials_0}
N 67510 920 67520 920 {lab=trials_0}
N 67510 470 86100 470 {lab=trials_0}
N 67510 470 67510 60 {lab=trials_0}
N 67510 60 67520 60 {lab=trials_0}
N 20480 1220 20470 1220 {lab=uo_out_4}
N 20470 1220 20470 1180 {lab=uo_out_4}
N 20470 1180 20270 1180 {lab=uo_out_4}
N 20470 1180 20470 1170 {lab=uo_out_4}
N 20270 1180 20270 210 {lab=uo_out_4}
N 20270 210 20280 210 {lab=uo_out_4}
N 20470 1170 40120 1170 {lab=uo_out_4}
N 40120 1170 40120 170 {lab=uo_out_4}
N 40120 1170 40120 1220 {lab=uo_out_4}
N 40120 1220 40120 1340 {lab=uo_out_4}
N 40120 1220 40420 1220 {lab=uo_out_4}
N 40420 1220 40420 1180 {lab=uo_out_4}
N 40420 1220 40440 1220 {lab=uo_out_4}
N 40120 170 40520 170 {lab=uo_out_4}
N 40120 170 40120 90 {lab=uo_out_4}
N 40520 170 40520 210 {lab=uo_out_4}
N 40520 210 40640 210 {lab=uo_out_4}
N 40420 1180 41280 1180 {lab=uo_out_4}
N 41280 1180 41280 1070 {lab=uo_out_4}
N 41280 1070 43220 1070 {lab=uo_out_4}
N 43220 1070 43220 1110 {lab=uo_out_4}
N 43220 1070 43240 1070 {lab=uo_out_4}
N 43220 1110 43320 1110 {lab=uo_out_4}
N 43320 1110 43320 1220 {lab=uo_out_4}
N 43320 1220 43630 1220 {lab=uo_out_4}
N 43630 1220 43990 1220 {lab=uo_out_4}
N 43630 1220 43630 250 {lab=uo_out_4}
N 43990 1220 44000 1220 {lab=uo_out_4}
N 43990 1220 43990 920 {lab=uo_out_4}
N 43630 250 43630 60 {lab=uo_out_4}
N 43630 250 44080 250 {lab=uo_out_4}
N 43630 60 43640 60 {lab=uo_out_4}
N 44080 250 44080 210 {lab=uo_out_4}
N 44080 210 44200 210 {lab=uo_out_4}
N 43990 920 49020 920 {lab=uo_out_4}
N 49020 920 49040 920 {lab=uo_out_4}
N 49020 920 49020 880 {lab=uo_out_4}
N 49020 880 49520 880 {lab=uo_out_4}
N 49520 880 67600 880 {lab=uo_out_4}
N 49520 880 49520 60 {lab=uo_out_4}
N 49520 60 49640 60 {lab=uo_out_4}
N 67600 880 67600 950 {lab=uo_out_4}
N 67600 950 86100 950 {lab=uo_out_4}
N 60240 1370 60230 1370 {lab=trials_1}
N 60230 1370 60230 1340 {lab=trials_1}
N 60230 1340 60230 1320 {lab=trials_1}
N 60230 1340 59920 1340 {lab=trials_1}
N 60230 1320 60320 1320 {lab=trials_1}
N 60320 1320 60320 1220 {lab=trials_1}
N 60320 1220 60430 1220 {lab=trials_1}
N 60430 1220 60430 210 {lab=trials_1}
N 60430 1220 60790 1220 {lab=trials_1}
N 60790 1220 60800 1220 {lab=trials_1}
N 60790 1220 60790 1270 {lab=trials_1}
N 60430 210 60430 100 {lab=trials_1}
N 60430 210 60800 210 {lab=trials_1}
N 60430 100 59920 100 {lab=trials_1}
N 60430 100 60430 60 {lab=trials_1}
N 60430 60 60440 60 {lab=trials_1}
N 59920 100 59920 90 {lab=trials_1}
N 60790 1270 62000 1270 {lab=trials_1}
N 62000 1270 62000 1370 {lab=trials_1}
N 62000 1370 62270 1370 {lab=trials_1}
N 62270 1370 62280 1370 {lab=trials_1}
N 62270 1370 62270 1320 {lab=trials_1}
N 62270 1320 62360 1320 {lab=trials_1}
N 62270 1320 62260 1320 {lab=trials_1}
N 62360 1320 62360 1220 {lab=trials_1}
N 62360 1220 62830 1220 {lab=trials_1}
N 62830 1220 62840 1220 {lab=trials_1}
N 62830 1220 62830 1180 {lab=trials_1}
N 62260 1320 62260 210 {lab=trials_1}
N 62260 210 62270 210 {lab=trials_1}
N 62270 210 62270 170 {lab=trials_1}
N 62270 210 62280 210 {lab=trials_1}
N 62270 170 62920 170 {lab=trials_1}
N 62920 170 62920 60 {lab=trials_1}
N 62920 60 63040 60 {lab=trials_1}
N 62830 1180 65000 1180 {lab=trials_1}
N 65000 1180 65000 1070 {lab=trials_1}
N 65000 1070 67510 1070 {lab=trials_1}
N 67510 1070 67510 1030 {lab=trials_1}
N 67510 1070 67520 1070 {lab=trials_1}
N 67510 1030 67610 1030 {lab=trials_1}
N 67610 1030 67610 510 {lab=trials_1}
N 67610 510 67610 60 {lab=trials_1}
N 67610 510 86100 510 {lab=trials_1}
N 67610 60 67720 60 {lab=trials_1}
N 18600 1220 18590 1220 {lab=_035_}
N 18590 1220 18590 1260 {lab=_035_}
N 18590 1220 18590 1180 {lab=_035_}
N 18590 1180 17470 1180 {lab=_035_}
N 18590 1180 18590 100 {lab=_035_}
N 18590 100 17670 100 {lab=_035_}
N 18590 100 18590 60 {lab=_035_}
N 18590 60 18600 60 {lab=_035_}
N 17470 1180 17470 590 {lab=_035_}
N 17470 1180 17470 1370 {lab=_035_}
N 17470 1370 17480 1370 {lab=_035_}
N 18590 1260 20000 1260 {lab=_035_}
N 20000 1260 20000 1370 {lab=_035_}
N 20000 1370 20260 1370 {lab=_035_}
N 20260 1370 20260 1260 {lab=_035_}
N 20260 1370 20280 1370 {lab=_035_}
N 17670 100 17670 60 {lab=_035_}
N 17670 60 17680 60 {lab=_035_}
N 20260 1260 22610 1260 {lab=_035_}
N 20260 1260 20260 170 {lab=_035_}
N 20260 170 20360 170 {lab=_035_}
N 20360 170 20360 60 {lab=_035_}
N 20360 60 20480 60 {lab=_035_}
N 22610 1260 22610 1220 {lab=_035_}
N 22610 1220 23070 1220 {lab=_035_}
N 23070 1220 23070 1260 {lab=_035_}
N 23070 1220 23070 100 {lab=_035_}
N 23070 1220 23080 1220 {lab=_035_}
N 23070 1260 23720 1260 {lab=_035_}
N 23720 1260 23720 1370 {lab=_035_}
N 23720 1370 23990 1370 {lab=_035_}
N 23990 1370 23990 1330 {lab=_035_}
N 23990 1370 24000 1370 {lab=_035_}
N 23070 100 23070 60 {lab=_035_}
N 23070 100 24080 100 {lab=_035_}
N 23070 60 23080 60 {lab=_035_}
N 23990 1330 24080 1330 {lab=_035_}
N 24080 1330 24080 1370 {lab=_035_}
N 24080 1370 24560 1370 {lab=_035_}
N 24080 100 24080 60 {lab=_035_}
N 24080 60 24190 60 {lab=_035_}
N 24190 60 24200 60 {lab=_035_}
N 24190 60 24190 100 {lab=_035_}
N 24190 100 24640 100 {lab=_035_}
N 24640 100 24640 60 {lab=_035_}
N 24640 60 24760 60 {lab=_035_}
N 17470 590 -60 590 {lab=_035_}
N 15600 1370 15590 1370 {lab=_034_}
N 15590 1370 15590 1320 {lab=_034_}
N 15590 1320 15190 1320 {lab=_034_}
N 15590 1320 18030 1320 {lab=_034_}
N 15190 1320 15190 550 {lab=_034_}
N 15190 550 -60 550 {lab=_034_}
N 15190 550 15190 360 {lab=_034_}
N 15190 360 15200 360 {lab=_034_}
N 18030 1320 18030 210 {lab=_034_}
N 18030 1320 18120 1320 {lab=_034_}
N 18120 1320 18120 1370 {lab=_034_}
N 18120 1370 18230 1370 {lab=_034_}
N 18230 1370 18240 1370 {lab=_034_}
N 18230 1370 18230 1430 {lab=_034_}
N 18030 210 18040 210 {lab=_034_}
N 18230 1430 19500 1430 {lab=_034_}
N 19500 1430 19500 360 {lab=_034_}
N 19500 1430 19800 1430 {lab=_034_}
N 19800 1430 19800 1370 {lab=_034_}
N 19800 1370 19910 1370 {lab=_034_}
N 19910 1370 19910 1330 {lab=_034_}
N 19910 1370 19920 1370 {lab=_034_}
N 19500 360 19520 360 {lab=_034_}
N 19910 1330 20830 1330 {lab=_034_}
N 20830 1330 20920 1330 {lab=_034_}
N 20830 1330 20830 250 {lab=_034_}
N 20920 1330 20920 1370 {lab=_034_}
N 20920 1370 21030 1370 {lab=_034_}
N 21030 1370 21040 1370 {lab=_034_}
N 21030 1370 21030 1330 {lab=_034_}
N 21030 1330 21480 1330 {lab=_034_}
N 21480 1330 21480 1370 {lab=_034_}
N 21480 1370 21590 1370 {lab=_034_}
N 21590 1370 21590 1330 {lab=_034_}
N 21590 1370 21600 1370 {lab=_034_}
N 20830 250 20830 210 {lab=_034_}
N 20830 250 20920 250 {lab=_034_}
N 20830 210 20840 210 {lab=_034_}
N 21590 1330 22040 1330 {lab=_034_}
N 22040 1330 22040 1370 {lab=_034_}
N 22040 1370 22160 1370 {lab=_034_}
N 20920 250 20920 210 {lab=_034_}
N 20920 210 21390 210 {lab=_034_}
N 21390 210 21390 250 {lab=_034_}
N 21390 210 21400 210 {lab=_034_}
N 21390 250 21480 250 {lab=_034_}
N 21480 250 21480 210 {lab=_034_}
N 21480 210 21960 210 {lab=_034_}
N 13720 1370 13710 1370 {lab=uo_out_0}
N 13710 1370 13710 1070 {lab=uo_out_0}
N 13710 1070 13710 170 {lab=uo_out_0}
N 13710 1070 14070 1070 {lab=uo_out_0}
N 14070 1070 14070 1270 {lab=uo_out_0}
N 14070 1070 14080 1070 {lab=uo_out_0}
N 13710 170 13510 170 {lab=uo_out_0}
N 13710 170 13710 60 {lab=uo_out_0}
N 13510 170 13510 60 {lab=uo_out_0}
N 13510 60 13520 60 {lab=uo_out_0}
N 13710 60 14080 60 {lab=uo_out_0}
N 14070 1270 27600 1270 {lab=uo_out_0}
N 27600 1270 27600 1340 {lab=uo_out_0}
N 27600 1270 27600 920 {lab=uo_out_0}
N 27600 920 27900 920 {lab=uo_out_0}
N 27600 920 27600 100 {lab=uo_out_0}
N 27900 920 27900 960 {lab=uo_out_0}
N 27900 920 27920 920 {lab=uo_out_0}
N 27600 100 27600 90 {lab=uo_out_0}
N 27600 100 28400 100 {lab=uo_out_0}
N 28400 100 28400 60 {lab=uo_out_0}
N 28400 60 28520 60 {lab=uo_out_0}
N 27900 960 28000 960 {lab=uo_out_0}
N 28000 960 28000 920 {lab=uo_out_0}
N 28000 920 31670 920 {lab=uo_out_0}
N 31670 920 31680 920 {lab=uo_out_0}
N 31670 920 31670 60 {lab=uo_out_0}
N 31670 60 31670 0 {lab=uo_out_0}
N 31670 60 31680 60 {lab=uo_out_0}
N 31670 0 86110 0 {lab=uo_out_0}
N 86110 0 86110 790 {lab=uo_out_0}
N 86110 790 86100 790 {lab=uo_out_0}
N 62480 1370 62470 1370 {lab=trials_2}
N 62470 1370 62470 1430 {lab=trials_2}
N 62470 1430 62560 1430 {lab=trials_2}
N 62470 1430 62260 1430 {lab=trials_2}
N 62560 1430 62560 1370 {lab=trials_2}
N 62560 1370 62830 1370 {lab=trials_2}
N 62830 1370 62830 1320 {lab=trials_2}
N 62830 1370 62840 1370 {lab=trials_2}
N 62260 1430 62260 1340 {lab=trials_2}
N 62260 1340 62250 1340 {lab=trials_2}
N 62250 1340 61960 1340 {lab=trials_2}
N 62250 1340 62250 100 {lab=trials_2}
N 62830 1320 63680 1320 {lab=trials_2}
N 63680 1320 63680 1220 {lab=trials_2}
N 63680 1220 63790 1220 {lab=trials_2}
N 63790 1220 63790 1170 {lab=trials_2}
N 63790 1220 63800 1220 {lab=trials_2}
N 62250 100 62250 90 {lab=trials_2}
N 62250 100 62360 100 {lab=trials_2}
N 62250 90 62250 60 {lab=trials_2}
N 62250 90 61960 90 {lab=trials_2}
N 62250 60 62280 60 {lab=trials_2}
N 62360 100 62360 60 {lab=trials_2}
N 62360 60 62840 60 {lab=trials_2}
N 63790 1170 63790 210 {lab=trials_2}
N 63790 1170 67040 1170 {lab=trials_2}
N 63790 210 63800 210 {lab=trials_2}
N 67040 1170 67040 1220 {lab=trials_2}
N 67040 1220 67510 1220 {lab=trials_2}
N 67510 1220 67510 1180 {lab=trials_2}
N 67510 1220 67520 1220 {lab=trials_2}
N 67510 1180 67800 1180 {lab=trials_2}
N 67800 1180 67800 550 {lab=trials_2}
N 67800 550 86100 550 {lab=trials_2}
N 67800 550 67800 60 {lab=trials_2}
N 67800 60 67920 60 {lab=trials_2}
N 71280 1370 71270 1370 {lab=trials_4}
N 71270 1370 71270 1320 {lab=trials_4}
N 71270 1320 71070 1320 {lab=trials_4}
N 71270 1320 71270 1220 {lab=trials_4}
N 71270 1220 71630 1220 {lab=trials_4}
N 71630 1220 71640 1220 {lab=trials_4}
N 71630 1220 71630 1260 {lab=trials_4}
N 71070 1320 71070 210 {lab=trials_4}
N 71070 1320 70760 1320 {lab=trials_4}
N 70760 1320 70760 1340 {lab=trials_4}
N 71630 1260 72280 1260 {lab=trials_4}
N 72280 1260 72280 1220 {lab=trials_4}
N 72280 1220 72390 1220 {lab=trials_4}
N 72390 1220 72400 1220 {lab=trials_4}
N 72390 1220 72390 1180 {lab=trials_4}
N 71070 210 71070 100 {lab=trials_4}
N 71070 210 71080 210 {lab=trials_4}
N 71070 100 71070 90 {lab=trials_4}
N 71070 100 71720 100 {lab=trials_4}
N 71070 90 70760 90 {lab=trials_4}
N 71720 100 71720 60 {lab=trials_4}
N 71720 60 71830 60 {lab=trials_4}
N 71830 60 71840 60 {lab=trials_4}
N 71830 60 71830 100 {lab=trials_4}
N 71830 100 72280 100 {lab=trials_4}
N 72280 100 72280 210 {lab=trials_4}
N 72280 210 72400 210 {lab=trials_4}
N 72390 1180 73600 1180 {lab=trials_4}
N 73600 1180 73600 1070 {lab=trials_4}
N 73600 1070 76110 1070 {lab=trials_4}
N 76110 1070 76110 630 {lab=trials_4}
N 76110 1070 76120 1070 {lab=trials_4}
N 76110 630 76110 60 {lab=trials_4}
N 76110 630 86100 630 {lab=trials_4}
N 76110 60 76120 60 {lab=trials_4}
N 80440 1370 80430 1370 {lab=trials_6}
N 80430 1370 80430 1320 {lab=trials_6}
N 80430 1320 80230 1320 {lab=trials_6}
N 80430 1320 80430 1220 {lab=trials_6}
N 80430 1220 80790 1220 {lab=trials_6}
N 80790 1220 80790 1260 {lab=trials_6}
N 80790 1220 80800 1220 {lab=trials_6}
N 80230 1320 79920 1320 {lab=trials_6}
N 80230 1320 80230 210 {lab=trials_6}
N 79920 1320 79920 1340 {lab=trials_6}
N 79920 1320 77630 1320 {lab=trials_6}
N 80790 1260 81440 1260 {lab=trials_6}
N 81440 1260 81440 1220 {lab=trials_6}
N 81440 1220 81550 1220 {lab=trials_6}
N 81550 1220 81550 710 {lab=trials_6}
N 81550 1220 81560 1220 {lab=trials_6}
N 80230 210 80240 210 {lab=trials_6}
N 80230 210 80230 100 {lab=trials_6}
N 80230 100 80880 100 {lab=trials_6}
N 80230 100 80230 90 {lab=trials_6}
N 80230 90 79920 90 {lab=trials_6}
N 80880 100 80880 60 {lab=trials_6}
N 80880 60 80990 60 {lab=trials_6}
N 80990 60 80990 100 {lab=trials_6}
N 80990 60 81000 60 {lab=trials_6}
N 80990 100 81440 100 {lab=trials_6}
N 81440 100 81440 210 {lab=trials_6}
N 81440 210 81560 210 {lab=trials_6}
N 77630 1320 77220 1320 {lab=trials_6}
N 77630 1320 77630 60 {lab=trials_6}
N 77220 1320 77220 1070 {lab=trials_6}
N 77220 1070 77240 1070 {lab=trials_6}
N 77630 60 77640 60 {lab=trials_6}
N 81550 710 86100 710 {lab=trials_6}
N 6480 1340 6480 90 {lab=_123_}
N 6480 1340 6520 1340 {lab=_123_}
N 6520 1340 6520 1460 {lab=_123_}
N 6520 1460 55480 1460 {lab=_123_}
N 55480 1460 55480 1370 {lab=_123_}
N 55480 1370 55740 1370 {lab=_123_}
N 55740 1370 55740 60 {lab=_123_}
N 55740 1370 55750 1370 {lab=_123_}
N 55750 1370 55760 1370 {lab=_123_}
N 55750 1370 55750 1450 {lab=_123_}
N 55740 60 55760 60 {lab=_123_}
N 55750 1450 63590 1450 {lab=_123_}
N 63590 1450 63680 1450 {lab=_123_}
N 63590 1450 63590 210 {lab=_123_}
N 63680 1450 63680 1430 {lab=_123_}
N 63680 1430 72190 1430 {lab=_123_}
N 63680 1430 63680 1370 {lab=_123_}
N 63680 1370 63800 1370 {lab=_123_}
N 63590 210 63600 210 {lab=_123_}
N 72190 1430 72190 210 {lab=_123_}
N 72190 1430 72280 1430 {lab=_123_}
N 72280 1430 81350 1430 {lab=_123_}
N 72280 1430 72280 1370 {lab=_123_}
N 72280 1370 72400 1370 {lab=_123_}
N 72190 210 72200 210 {lab=_123_}
N 81350 1430 81440 1430 {lab=_123_}
N 81350 1430 81350 210 {lab=_123_}
N 81440 1430 81440 1370 {lab=_123_}
N 81440 1370 81560 1370 {lab=_123_}
N 81350 210 81360 210 {lab=_123_}
N 43280 1040 43280 100 {lab=_050_}
N 43280 1040 44080 1040 {lab=_050_}
N 43280 100 43480 100 {lab=_050_}
N 43280 100 43280 90 {lab=_050_}
N 43480 100 43480 90 {lab=_050_}
N 43480 100 43680 100 {lab=_050_}
N 43680 100 44080 100 {lab=_050_}
N 43680 100 43680 90 {lab=_050_}
N 44080 1040 44080 1220 {lab=_050_}
N 44080 1220 44550 1220 {lab=_050_}
N 44550 1220 44550 1260 {lab=_050_}
N 44550 1220 44560 1220 {lab=_050_}
N 44080 100 44080 60 {lab=_050_}
N 44080 60 44560 60 {lab=_050_}
N 44550 1260 49120 1260 {lab=_050_}
N 49120 1260 49120 1370 {lab=_050_}
N 49120 1370 49990 1370 {lab=_050_}
N 49990 1370 50000 1370 {lab=_050_}
N 49990 1370 49990 1320 {lab=_050_}
N 49990 1320 50640 1320 {lab=_050_}
N 49990 1320 49990 250 {lab=_050_}
N 49990 250 50640 250 {lab=_050_}
N 49990 250 49990 210 {lab=_050_}
N 49990 210 50000 210 {lab=_050_}
N 50640 1320 50640 1370 {lab=_050_}
N 50640 1370 50760 1370 {lab=_050_}
N 50640 250 50640 210 {lab=_050_}
N 50640 210 50760 210 {lab=_050_}
N 55960 1370 55950 1370 {lab=_124_}
N 55950 1370 55950 1470 {lab=_124_}
N 55950 1370 55950 1170 {lab=_124_}
N 55950 1170 55950 60 {lab=_124_}
N 55950 1170 62920 1170 {lab=_124_}
N 55950 60 55960 60 {lab=_124_}
N 62920 1170 62920 1220 {lab=_124_}
N 62920 1220 63580 1220 {lab=_124_}
N 63580 1220 63580 1160 {lab=_124_}
N 63580 1220 63600 1220 {lab=_124_}
N 63580 1160 63580 170 {lab=_124_}
N 63580 1160 71720 1160 {lab=_124_}
N 63580 170 63680 170 {lab=_124_}
N 63680 170 63680 60 {lab=_124_}
N 63680 60 63800 60 {lab=_124_}
N 71720 1160 71720 1220 {lab=_124_}
N 71720 1220 72180 1220 {lab=_124_}
N 72180 1220 72180 1170 {lab=_124_}
N 72180 1220 72200 1220 {lab=_124_}
N 72180 1170 72180 170 {lab=_124_}
N 72180 1170 80880 1170 {lab=_124_}
N 72180 170 72290 170 {lab=_124_}
N 72290 170 72290 60 {lab=_124_}
N 72290 60 72400 60 {lab=_124_}
N 80880 1170 80880 1220 {lab=_124_}
N 80880 1220 81340 1220 {lab=_124_}
N 81340 1220 81360 1220 {lab=_124_}
N 81340 1220 81340 170 {lab=_124_}
N 81340 170 81450 170 {lab=_124_}
N 81450 170 81450 60 {lab=_124_}
N 81450 60 81560 60 {lab=_124_}
N 55950 1470 -70 1470 {lab=_124_}
N -70 1470 -70 870 {lab=_124_}
N -70 870 -60 870 {lab=_124_}
N 24200 1220 24190 1220 {lab=trials_3}
N 24190 1220 24190 1180 {lab=trials_3}
N 24190 1220 24190 1480 {lab=trials_3}
N 24190 1180 23990 1180 {lab=trials_3}
N 23990 1180 23990 210 {lab=trials_3}
N 23990 210 24000 210 {lab=trials_3}
N 24190 1480 66680 1480 {lab=trials_3}
N 66680 1480 66680 1340 {lab=trials_3}
N 66680 1340 66640 1340 {lab=trials_3}
N 66680 1340 66680 1220 {lab=trials_3}
N 66680 1220 66950 1220 {lab=trials_3}
N 66680 1220 66640 1220 {lab=trials_3}
N 66950 1220 66950 1260 {lab=trials_3}
N 66950 1220 66960 1220 {lab=trials_3}
N 66950 1260 67240 1260 {lab=trials_3}
N 67240 1260 67240 1370 {lab=trials_3}
N 67240 1370 67520 1370 {lab=trials_3}
N 66640 1220 66640 250 {lab=trials_3}
N 66640 250 67040 250 {lab=trials_3}
N 66640 250 66640 90 {lab=trials_3}
N 67040 250 67040 210 {lab=trials_3}
N 67040 210 67150 210 {lab=trials_3}
N 67150 210 67160 210 {lab=trials_3}
N 67150 210 67150 170 {lab=trials_3}
N 67150 170 68000 170 {lab=trials_3}
N 68000 170 68000 60 {lab=trials_3}
N 68000 60 68110 60 {lab=trials_3}
N 68110 60 68120 60 {lab=trials_3}
N 68110 60 68110 -10 {lab=trials_3}
N 68110 -10 86120 -10 {lab=trials_3}
N 86120 -10 86120 590 {lab=trials_3}
N 86120 590 86100 590 {lab=trials_3}
N 24760 1220 24750 1220 {lab=trials_5}
N 24750 1220 24750 1490 {lab=trials_5}
N 24750 1220 24750 1180 {lab=trials_5}
N 24750 1180 24550 1180 {lab=trials_5}
N 24550 1180 24550 210 {lab=trials_5}
N 24550 210 24560 210 {lab=trials_5}
N 24750 1490 75280 1490 {lab=trials_5}
N 75280 1490 75280 1340 {lab=trials_5}
N 75280 1340 75240 1340 {lab=trials_5}
N 75280 1340 75280 1220 {lab=trials_5}
N 75280 1220 75550 1220 {lab=trials_5}
N 75280 1220 75240 1220 {lab=trials_5}
N 75550 1220 75550 1260 {lab=trials_5}
N 75550 1220 75560 1220 {lab=trials_5}
N 75550 1260 75640 1260 {lab=trials_5}
N 75640 1260 75640 1220 {lab=trials_5}
N 75640 1220 76120 1220 {lab=trials_5}
N 75240 1220 75240 250 {lab=trials_5}
N 75240 250 75640 250 {lab=trials_5}
N 75240 250 75240 90 {lab=trials_5}
N 75640 250 75640 210 {lab=trials_5}
N 75640 210 75750 210 {lab=trials_5}
N 75750 210 75760 210 {lab=trials_5}
N 75750 210 75750 170 {lab=trials_5}
N 75750 170 76200 170 {lab=trials_5}
N 76200 170 76200 60 {lab=trials_5}
N 76200 60 76310 60 {lab=trials_5}
N 76310 60 76320 60 {lab=trials_5}
N 76310 60 76310 -20 {lab=trials_5}
N 76310 -20 86130 -20 {lab=trials_5}
N 86130 -20 86130 670 {lab=trials_5}
N 86130 670 86100 670 {lab=trials_5}
N 27920 1070 27900 1070 {lab=uo_out_1}
N 27900 1070 27900 1030 {lab=uo_out_1}
N 27900 1030 28200 1030 {lab=uo_out_1}
N 28200 1030 30800 1030 {lab=uo_out_1}
N 28200 1030 28200 60 {lab=uo_out_1}
N 28200 60 28320 60 {lab=uo_out_1}
N 30800 1030 30800 1260 {lab=uo_out_1}
N 30800 1030 30800 210 {lab=uo_out_1}
N 30800 1260 31200 1260 {lab=uo_out_1}
N 30800 1260 30800 1340 {lab=uo_out_1}
N 31200 1260 31200 1220 {lab=uo_out_1}
N 31200 1220 31310 1220 {lab=uo_out_1}
N 31310 1220 31320 1220 {lab=uo_out_1}
N 31310 1220 31310 1070 {lab=uo_out_1}
N 31310 1070 31680 1070 {lab=uo_out_1}
N 30800 210 31110 210 {lab=uo_out_1}
N 30800 210 30800 90 {lab=uo_out_1}
N 31110 210 31110 170 {lab=uo_out_1}
N 31110 210 31120 210 {lab=uo_out_1}
N 31110 170 31760 170 {lab=uo_out_1}
N 31760 170 31760 60 {lab=uo_out_1}
N 31760 60 31870 60 {lab=uo_out_1}
N 31870 60 31880 60 {lab=uo_out_1}
N 31870 60 31870 -30 {lab=uo_out_1}
N 31870 -30 86140 -30 {lab=uo_out_1}
N 86140 -30 86140 830 {lab=uo_out_1}
N 86140 830 86100 830 {lab=uo_out_1}
N 43240 1220 43220 1220 {lab=uo_out_5}
N 43220 1220 42920 1220 {lab=uo_out_5}
N 43220 1220 43220 1260 {lab=uo_out_5}
N 42920 1220 42920 1340 {lab=uo_out_5}
N 43220 1260 43430 1260 {lab=uo_out_5}
N 43430 1260 44080 1260 {lab=uo_out_5}
N 43430 1260 43430 110 {lab=uo_out_5}
N 44080 1260 44080 1270 {lab=uo_out_5}
N 44080 1270 44080 1370 {lab=uo_out_5}
N 44080 1270 47080 1270 {lab=uo_out_5}
N 44080 1370 44200 1370 {lab=uo_out_5}
N 43430 110 42920 110 {lab=uo_out_5}
N 43430 110 43430 60 {lab=uo_out_5}
N 43430 110 43720 110 {lab=uo_out_5}
N 43430 60 43440 60 {lab=uo_out_5}
N 42920 110 42920 90 {lab=uo_out_5}
N 43720 110 43720 60 {lab=uo_out_5}
N 43720 60 44000 60 {lab=uo_out_5}
N 47080 1270 47080 1070 {lab=uo_out_5}
N 47080 1070 49020 1070 {lab=uo_out_5}
N 49020 1070 49020 1030 {lab=uo_out_5}
N 49020 1070 49040 1070 {lab=uo_out_5}
N 49020 1030 49320 1030 {lab=uo_out_5}
N 49320 1030 49320 60 {lab=uo_out_5}
N 49320 60 49430 60 {lab=uo_out_5}
N 49430 60 49440 60 {lab=uo_out_5}
N 49430 60 49430 -40 {lab=uo_out_5}
N 49430 -40 86150 -40 {lab=uo_out_5}
N 86150 -40 86150 990 {lab=uo_out_5}
N 86150 990 86100 990 {lab=uo_out_5}
N 49040 1220 49020 1220 {lab=uo_out_6}
N 49020 1220 49020 1180 {lab=uo_out_6}
N 49020 1220 48720 1220 {lab=uo_out_6}
N 48720 1220 48720 1340 {lab=uo_out_6}
N 49020 1180 49230 1180 {lab=uo_out_6}
N 49230 1180 49230 100 {lab=uo_out_6}
N 49230 1180 50080 1180 {lab=uo_out_6}
N 50080 1180 50080 1220 {lab=uo_out_6}
N 50080 1220 50550 1220 {lab=uo_out_6}
N 50080 1220 50080 1370 {lab=uo_out_6}
N 50080 1370 50200 1370 {lab=uo_out_6}
N 49230 100 49720 100 {lab=uo_out_6}
N 49230 100 48720 100 {lab=uo_out_6}
N 49230 100 49230 60 {lab=uo_out_6}
N 49230 60 49240 60 {lab=uo_out_6}
N 48720 100 48720 90 {lab=uo_out_6}
N 50550 1220 50550 1500 {lab=uo_out_6}
N 50550 1220 50560 1220 {lab=uo_out_6}
N 49720 100 49720 60 {lab=uo_out_6}
N 49720 60 49990 60 {lab=uo_out_6}
N 49990 60 49990 100 {lab=uo_out_6}
N 49990 60 50000 60 {lab=uo_out_6}
N 49990 100 50080 100 {lab=uo_out_6}
N 50080 100 50080 210 {lab=uo_out_6}
N 50080 210 50560 210 {lab=uo_out_6}
N 50550 1500 84640 1500 {lab=uo_out_6}
N 84640 1500 84640 1030 {lab=uo_out_6}
N 84640 1030 86100 1030 {lab=uo_out_6}
N 13520 1220 13500 1220 {lab=event_pending}
N 13500 1220 13500 1260 {lab=event_pending}
N 13500 1260 13600 1260 {lab=event_pending}
N 13600 1260 13600 1220 {lab=event_pending}
N 13600 1220 13700 1220 {lab=event_pending}
N 13700 1220 13700 950 {lab=event_pending}
N 13700 1220 14060 1220 {lab=event_pending}
N 14060 1220 14060 1280 {lab=event_pending}
N 14060 1220 14080 1220 {lab=event_pending}
N 13700 950 13700 260 {lab=event_pending}
N 13700 950 -60 950 {lab=event_pending}
N 13700 260 13700 210 {lab=event_pending}
N 13700 260 14160 260 {lab=event_pending}
N 13700 210 13720 210 {lab=event_pending}
N 14160 260 14160 60 {lab=event_pending}
N 14160 60 14280 60 {lab=event_pending}
N 14060 1280 27610 1280 {lab=event_pending}
N 27610 1280 27610 1220 {lab=event_pending}
N 27610 1220 27890 1220 {lab=event_pending}
N 27890 1220 27900 1220 {lab=event_pending}
N 27890 1220 27890 1020 {lab=event_pending}
N 27900 1220 27900 1270 {lab=event_pending}
N 27900 1220 27920 1220 {lab=event_pending}
N 27890 1020 28010 1020 {lab=event_pending}
N 28010 1020 28010 60 {lab=event_pending}
N 28010 60 28120 60 {lab=event_pending}
N 27900 1270 31200 1270 {lab=event_pending}
N 31200 1270 31200 1370 {lab=event_pending}
N 31200 1370 31670 1370 {lab=event_pending}
N 31670 1370 31680 1370 {lab=event_pending}
N 31670 1370 31670 1310 {lab=event_pending}
N 31670 1310 32160 1310 {lab=event_pending}
N 32160 1310 32160 60 {lab=event_pending}
N 32160 60 32280 60 {lab=event_pending}
N 320 1370 310 1370 {lab=_120_}
N 310 1370 310 1320 {lab=_120_}
N 310 1320 12550 1320 {lab=_120_}
N 310 1320 310 790 {lab=_120_}
N 310 790 110 790 {lab=_120_}
N 110 790 -60 790 {lab=_120_}
N 110 790 110 60 {lab=_120_}
N 110 60 120 60 {lab=_120_}
N 12550 1320 12550 210 {lab=_120_}
N 12550 1320 12640 1320 {lab=_120_}
N 12640 1320 12640 1370 {lab=_120_}
N 12640 1370 12750 1370 {lab=_120_}
N 12750 1370 12760 1370 {lab=_120_}
N 12750 1370 12750 1450 {lab=_120_}
N 12550 210 12560 210 {lab=_120_}
N 12750 1450 15950 1450 {lab=_120_}
N 15950 1450 15950 250 {lab=_120_}
N 15950 1450 16040 1450 {lab=_120_}
N 16040 1450 16040 1430 {lab=_120_}
N 16040 1430 16040 1370 {lab=_120_}
N 16040 1430 16800 1430 {lab=_120_}
N 16040 1370 16160 1370 {lab=_120_}
N 16800 1430 16800 1370 {lab=_120_}
N 16800 1370 16920 1370 {lab=_120_}
N 15950 250 16040 250 {lab=_120_}
N 15950 250 15950 210 {lab=_120_}
N 15950 210 15960 210 {lab=_120_}
N 16040 250 16040 210 {lab=_120_}
N 16040 210 16720 210 {lab=_120_}
N 27960 890 27960 110 {lab=_042_}
N 27960 890 30840 890 {lab=_042_}
N 27960 110 28160 110 {lab=_042_}
N 27960 110 27960 90 {lab=_042_}
N 28160 110 28360 110 {lab=_042_}
N 28160 110 28160 90 {lab=_042_}
N 28360 110 28360 90 {lab=_042_}
N 28360 110 28560 110 {lab=_042_}
N 28560 110 28560 90 {lab=_042_}
N 30840 890 31200 890 {lab=_042_}
N 30840 890 30840 1370 {lab=_042_}
N 30840 1370 31110 1370 {lab=_042_}
N 31110 1370 31110 1440 {lab=_042_}
N 31110 1370 31120 1370 {lab=_042_}
N 31200 890 31200 60 {lab=_042_}
N 31200 60 31320 60 {lab=_042_}
N 31110 1440 32980 1440 {lab=_042_}
N 32980 1440 32980 210 {lab=_042_}
N 32980 1440 33080 1440 {lab=_042_}
N 33080 1440 33080 1370 {lab=_042_}
N 33080 1370 33200 1370 {lab=_042_}
N 32980 210 33000 210 {lab=_042_}
N 49080 890 49080 110 {lab=_053_}
N 49080 890 53080 890 {lab=_053_}
N 49080 110 49280 110 {lab=_053_}
N 49080 110 49080 90 {lab=_053_}
N 49280 110 49480 110 {lab=_053_}
N 49280 110 49280 90 {lab=_053_}
N 49480 110 49480 90 {lab=_053_}
N 49480 110 49680 110 {lab=_053_}
N 49680 110 49680 90 {lab=_053_}
N 53080 890 53080 1370 {lab=_053_}
N 53080 890 53080 210 {lab=_053_}
N 53080 1370 53350 1370 {lab=_053_}
N 53350 1370 53350 1430 {lab=_053_}
N 53350 1370 53360 1370 {lab=_053_}
N 53080 210 53350 210 {lab=_053_}
N 53350 210 53360 210 {lab=_053_}
N 53350 210 53350 250 {lab=_053_}
N 53350 1430 54000 1430 {lab=_053_}
N 54000 1430 54000 1370 {lab=_053_}
N 54000 1370 54120 1370 {lab=_053_}
N 53350 250 54000 250 {lab=_053_}
N 54000 250 54000 210 {lab=_053_}
N 54000 210 54120 210 {lab=_053_}
N 6120 1340 6120 1330 {lab=274.ncki}
N 6120 1330 11920 1330 {lab=274.ncki}
N 6120 1330 6120 90 {lab=274.ncki}
N 11920 1330 11920 1370 {lab=274.ncki}
N 11920 1370 12190 1370 {lab=274.ncki}
N 12190 1370 12190 60 {lab=274.ncki}
N 12190 1370 12190 1510 {lab=274.ncki}
N 12190 1370 12200 1370 {lab=274.ncki}
N 12190 60 12200 60 {lab=274.ncki}
N 12190 1510 83520 1510 {lab=274.ncki}
N 83520 1510 83520 1220 {lab=274.ncki}
N 83520 1220 83790 1220 {lab=274.ncki}
N 83790 1220 83790 1180 {lab=274.ncki}
N 83790 1220 83800 1220 {lab=274.ncki}
N 83790 1180 83880 1180 {lab=274.ncki}
N 83880 1180 83880 210 {lab=274.ncki}
N 83880 1180 85200 1180 {lab=274.ncki}
N 83880 210 84180 210 {lab=274.ncki}
N 84180 210 84180 250 {lab=274.ncki}
N 84180 210 84200 210 {lab=274.ncki}
N 85200 1180 85200 1220 {lab=274.ncki}
N 85200 1220 85320 1220 {lab=274.ncki}
N 84180 250 84280 250 {lab=274.ncki}
N 84280 250 84280 210 {lab=274.ncki}
N 84280 210 85120 210 {lab=274.ncki}
N 5760 1340 5760 1310 {lab=273.ncki}
N 5760 1310 5760 90 {lab=273.ncki}
N 5760 1310 11560 1310 {lab=273.ncki}
N 11560 1310 11560 1370 {lab=273.ncki}
N 11560 1370 11830 1370 {lab=273.ncki}
N 11830 1370 11840 1370 {lab=273.ncki}
N 11830 1370 11830 1520 {lab=273.ncki}
N 11830 1370 11830 60 {lab=273.ncki}
N 11830 60 11840 60 {lab=273.ncki}
N 11830 1520 81640 1520 {lab=273.ncki}
N 81640 1520 81640 1220 {lab=273.ncki}
N 81640 1220 82470 1220 {lab=273.ncki}
N 82470 1220 82470 1260 {lab=273.ncki}
N 82470 1220 82480 1220 {lab=273.ncki}
N 82470 1260 82860 1260 {lab=273.ncki}
N 82860 1260 82860 250 {lab=273.ncki}
N 82860 1260 83320 1260 {lab=273.ncki}
N 83320 1260 83320 1220 {lab=273.ncki}
N 83320 1220 83440 1220 {lab=273.ncki}
N 82860 250 82860 210 {lab=273.ncki}
N 82860 250 82960 250 {lab=273.ncki}
N 82860 210 82880 210 {lab=273.ncki}
N 82960 250 82960 210 {lab=273.ncki}
N 82960 210 83240 210 {lab=273.ncki}
N 5400 1340 5400 1300 {lab=272.ncki}
N 5400 1300 11200 1300 {lab=272.ncki}
N 5400 1300 5400 90 {lab=272.ncki}
N 11200 1300 11200 1370 {lab=272.ncki}
N 11200 1370 11470 1370 {lab=272.ncki}
N 11470 1370 11480 1370 {lab=272.ncki}
N 11470 1370 11470 60 {lab=272.ncki}
N 11470 1370 11470 1530 {lab=272.ncki}
N 11470 60 11480 60 {lab=272.ncki}
N 11470 1530 77640 1530 {lab=272.ncki}
N 77640 1530 77640 1220 {lab=272.ncki}
N 77640 1220 77990 1220 {lab=272.ncki}
N 77990 1220 77990 1260 {lab=272.ncki}
N 77990 1220 78000 1220 {lab=272.ncki}
N 77990 1260 78380 1260 {lab=272.ncki}
N 78380 1260 78380 250 {lab=272.ncki}
N 78380 1260 78840 1260 {lab=272.ncki}
N 78840 1260 78840 1220 {lab=272.ncki}
N 78840 1220 78960 1220 {lab=272.ncki}
N 78380 250 78380 210 {lab=272.ncki}
N 78380 250 78480 250 {lab=272.ncki}
N 78380 210 78400 210 {lab=272.ncki}
N 78480 250 78480 210 {lab=272.ncki}
N 78480 210 78760 210 {lab=272.ncki}
N 5040 1340 5040 90 {lab=271.ncki}
N 5040 1340 5090 1340 {lab=271.ncki}
N 5090 1340 5090 1430 {lab=271.ncki}
N 5090 1430 10840 1430 {lab=271.ncki}
N 10840 1430 10840 1370 {lab=271.ncki}
N 10840 1370 11110 1370 {lab=271.ncki}
N 11110 1370 11110 60 {lab=271.ncki}
N 11110 1370 11110 1540 {lab=271.ncki}
N 11110 1370 11120 1370 {lab=271.ncki}
N 11110 60 11120 60 {lab=271.ncki}
N 11110 1540 72480 1540 {lab=271.ncki}
N 72480 1540 72480 1220 {lab=271.ncki}
N 72480 1220 73310 1220 {lab=271.ncki}
N 73310 1220 73310 1260 {lab=271.ncki}
N 73310 1220 73320 1220 {lab=271.ncki}
N 73310 1260 73700 1260 {lab=271.ncki}
N 73700 1260 74160 1260 {lab=271.ncki}
N 73700 1260 73700 250 {lab=271.ncki}
N 74160 1260 74160 1220 {lab=271.ncki}
N 74160 1220 74280 1220 {lab=271.ncki}
N 73700 250 73800 250 {lab=271.ncki}
N 73700 250 73700 210 {lab=271.ncki}
N 73700 210 73720 210 {lab=271.ncki}
N 73800 250 73800 210 {lab=271.ncki}
N 73800 210 74080 210 {lab=271.ncki}
N 4680 1340 4680 1290 {lab=270.ncki}
N 4680 1290 4680 90 {lab=270.ncki}
N 4680 1290 10480 1290 {lab=270.ncki}
N 10480 1290 10480 1370 {lab=270.ncki}
N 10480 1370 10750 1370 {lab=270.ncki}
N 10750 1370 10750 1550 {lab=270.ncki}
N 10750 1370 10760 1370 {lab=270.ncki}
N 10750 1370 10750 60 {lab=270.ncki}
N 10750 60 10760 60 {lab=270.ncki}
N 10750 1550 67600 1550 {lab=270.ncki}
N 67600 1550 67600 1220 {lab=270.ncki}
N 67600 1220 68830 1220 {lab=270.ncki}
N 68830 1220 68830 1260 {lab=270.ncki}
N 68830 1220 68840 1220 {lab=270.ncki}
N 68830 1260 69220 1260 {lab=270.ncki}
N 69220 1260 69220 250 {lab=270.ncki}
N 69220 1260 69680 1260 {lab=270.ncki}
N 69680 1260 69680 1220 {lab=270.ncki}
N 69680 1220 69800 1220 {lab=270.ncki}
N 69220 250 69320 250 {lab=270.ncki}
N 69220 250 69220 210 {lab=270.ncki}
N 69220 210 69240 210 {lab=270.ncki}
N 69320 250 69320 210 {lab=270.ncki}
N 69320 210 69600 210 {lab=270.ncki}
N 4320 1340 4370 1340 {lab=269.ncki}
N 4320 1340 4320 90 {lab=269.ncki}
N 4370 1340 4370 1440 {lab=269.ncki}
N 4370 1440 10120 1440 {lab=269.ncki}
N 10120 1440 10120 1370 {lab=269.ncki}
N 10120 1370 10390 1370 {lab=269.ncki}
N 10390 1370 10390 1560 {lab=269.ncki}
N 10390 1370 10400 1370 {lab=269.ncki}
N 10390 1370 10390 60 {lab=269.ncki}
N 10390 60 10400 60 {lab=269.ncki}
N 10390 1560 63880 1560 {lab=269.ncki}
N 63880 1560 63880 1220 {lab=269.ncki}
N 63880 1220 64710 1220 {lab=269.ncki}
N 64710 1220 64710 1260 {lab=269.ncki}
N 64710 1220 64720 1220 {lab=269.ncki}
N 64710 1260 65100 1260 {lab=269.ncki}
N 65100 1260 65100 250 {lab=269.ncki}
N 65100 1260 65560 1260 {lab=269.ncki}
N 65560 1260 65560 1220 {lab=269.ncki}
N 65560 1220 65680 1220 {lab=269.ncki}
N 65100 250 65100 210 {lab=269.ncki}
N 65100 250 65200 250 {lab=269.ncki}
N 65100 210 65120 210 {lab=269.ncki}
N 65200 250 65200 210 {lab=269.ncki}
N 65200 210 65480 210 {lab=269.ncki}
N 77280 1040 77280 1030 {lab=_073_}
N 77280 1030 77280 100 {lab=_073_}
N 77280 1030 77210 1030 {lab=_073_}
N 77280 100 77480 100 {lab=_073_}
N 77280 100 77280 90 {lab=_073_}
N 77480 100 77480 90 {lab=_073_}
N 77480 100 77680 100 {lab=_073_}
N 77680 100 77680 90 {lab=_073_}
N 77210 1030 77210 1570 {lab=_073_}
N 77210 1570 25110 1570 {lab=_073_}
N 25110 1570 25110 1500 {lab=_073_}
N 25110 1500 17460 1500 {lab=_073_}
N 25110 1500 25110 1370 {lab=_073_}
N 25110 1370 25110 210 {lab=_073_}
N 25110 1370 25120 1370 {lab=_073_}
N 25110 210 25120 210 {lab=_073_}
N 17460 1500 17460 1220 {lab=_073_}
N 17460 1220 17480 1220 {lab=_073_}
N 17460 1220 17460 60 {lab=_073_}
N 17460 60 17480 60 {lab=_073_}
N 16760 1340 16760 1310 {lab=_067_}
N 16760 1310 16760 390 {lab=_067_}
N 16760 1310 16960 1310 {lab=_067_}
N 16960 1310 16960 1340 {lab=_067_}
N 16960 1310 17160 1310 {lab=_067_}
N 17160 1310 17160 1340 {lab=_067_}
N 17160 1310 24280 1310 {lab=_067_}
N 24280 1310 24280 1220 {lab=_067_}
N 24280 1220 24540 1220 {lab=_067_}
N 24540 1220 24540 60 {lab=_067_}
N 24540 1220 24550 1220 {lab=_067_}
N 24550 1220 24550 1580 {lab=_067_}
N 24550 1220 24560 1220 {lab=_067_}
N 24540 60 24560 60 {lab=_067_}
N 24550 1580 75290 1580 {lab=_067_}
N 75290 1580 75290 1370 {lab=_067_}
N 75290 1370 75540 1370 {lab=_067_}
N 75540 1370 75560 1370 {lab=_067_}
N 75540 1370 75540 210 {lab=_067_}
N 75540 210 75560 210 {lab=_067_}
N 3960 1340 3960 90 {lab=268.ncki}
N 3960 1340 4010 1340 {lab=268.ncki}
N 4010 1340 4010 1450 {lab=268.ncki}
N 4010 1450 9760 1450 {lab=268.ncki}
N 9760 1450 9760 1370 {lab=268.ncki}
N 9760 1370 10030 1370 {lab=268.ncki}
N 10030 1370 10030 1590 {lab=268.ncki}
N 10030 1370 10030 60 {lab=268.ncki}
N 10030 1370 10040 1370 {lab=268.ncki}
N 10030 60 10040 60 {lab=268.ncki}
N 10030 1590 57720 1590 {lab=268.ncki}
N 57720 1590 57720 1220 {lab=268.ncki}
N 57720 1220 57990 1220 {lab=268.ncki}
N 57990 1220 57990 1180 {lab=268.ncki}
N 57990 1220 58000 1220 {lab=268.ncki}
N 57990 1180 58080 1180 {lab=268.ncki}
N 58080 1180 58080 210 {lab=268.ncki}
N 58080 1180 59310 1180 {lab=268.ncki}
N 58080 210 58400 210 {lab=268.ncki}
N 59310 1180 59310 210 {lab=268.ncki}
N 59310 1180 59400 1180 {lab=268.ncki}
N 59400 1180 59400 1220 {lab=268.ncki}
N 59400 1220 59520 1220 {lab=268.ncki}
N 59310 210 59320 210 {lab=268.ncki}
N 3600 1340 3600 1280 {lab=267.ncki}
N 3600 1280 3600 90 {lab=267.ncki}
N 3600 1280 9400 1280 {lab=267.ncki}
N 9400 1280 9400 1370 {lab=267.ncki}
N 9400 1280 9400 60 {lab=267.ncki}
N 9400 1370 9670 1370 {lab=267.ncki}
N 9670 1370 9670 1600 {lab=267.ncki}
N 9670 1370 9680 1370 {lab=267.ncki}
N 9400 60 9680 60 {lab=267.ncki}
N 9670 1600 56040 1600 {lab=267.ncki}
N 56040 1600 56040 1220 {lab=267.ncki}
N 56040 1220 56670 1220 {lab=267.ncki}
N 56670 1220 56680 1220 {lab=267.ncki}
N 56670 1220 56670 1180 {lab=267.ncki}
N 56670 1180 57060 1180 {lab=267.ncki}
N 57060 1180 57060 250 {lab=267.ncki}
N 57060 1180 57520 1180 {lab=267.ncki}
N 57520 1180 57520 1220 {lab=267.ncki}
N 57520 1220 57640 1220 {lab=267.ncki}
N 57060 250 57160 250 {lab=267.ncki}
N 57060 250 57060 210 {lab=267.ncki}
N 57060 210 57080 210 {lab=267.ncki}
N 57160 250 57160 210 {lab=267.ncki}
N 57160 210 57440 210 {lab=267.ncki}
N 16000 1340 16000 1310 {lab=_061_}
N 16000 1310 16000 390 {lab=_061_}
N 16000 1310 16200 1310 {lab=_061_}
N 16200 1310 16200 1340 {lab=_061_}
N 16200 1310 16400 1310 {lab=_061_}
N 16400 1310 16400 1300 {lab=_061_}
N 16400 1310 16400 1340 {lab=_061_}
N 16400 1300 23160 1300 {lab=_061_}
N 23160 1300 23160 1220 {lab=_061_}
N 23160 1220 23980 1220 {lab=_061_}
N 23980 1220 24000 1220 {lab=_061_}
N 23980 1220 23980 1610 {lab=_061_}
N 23980 1220 23980 60 {lab=_061_}
N 23980 60 24000 60 {lab=_061_}
N 23980 1610 66690 1610 {lab=_061_}
N 66690 1610 66690 1370 {lab=_061_}
N 66690 1370 66940 1370 {lab=_061_}
N 66940 1370 66960 1370 {lab=_061_}
N 66940 1370 66940 210 {lab=_061_}
N 66940 210 66960 210 {lab=_061_}
N 3240 1340 3290 1340 {lab=266.ncki}
N 3240 1340 3240 90 {lab=266.ncki}
N 3290 1340 3290 1480 {lab=266.ncki}
N 3290 1480 9040 1480 {lab=266.ncki}
N 9040 1480 9040 1370 {lab=266.ncki}
N 9040 1370 9310 1370 {lab=266.ncki}
N 9310 1370 9320 1370 {lab=266.ncki}
N 9310 1370 9310 60 {lab=266.ncki}
N 9310 60 9320 60 {lab=266.ncki}
N 9310 60 9310 -10 {lab=266.ncki}
N 9310 -10 50840 -10 {lab=266.ncki}
N 50840 -10 50840 250 {lab=266.ncki}
N 50840 250 50840 1220 {lab=266.ncki}
N 50840 250 51200 250 {lab=266.ncki}
N 50840 1220 51110 1220 {lab=266.ncki}
N 51110 1220 51110 1260 {lab=266.ncki}
N 51110 1220 51120 1220 {lab=266.ncki}
N 51200 250 51200 210 {lab=266.ncki}
N 51200 210 51520 210 {lab=266.ncki}
N 51110 1260 52430 1260 {lab=266.ncki}
N 52430 1260 52430 210 {lab=266.ncki}
N 52430 1260 52520 1260 {lab=266.ncki}
N 52520 1260 52520 1220 {lab=266.ncki}
N 52520 1220 52640 1220 {lab=266.ncki}
N 52430 210 52440 210 {lab=266.ncki}
N 62880 1040 62880 100 {lab=_059_}
N 62880 1040 62930 1040 {lab=_059_}
N 62880 100 63080 100 {lab=_059_}
N 62880 100 62880 90 {lab=_059_}
N 62930 1040 62930 1370 {lab=_059_}
N 62930 1370 62930 1620 {lab=_059_}
N 62930 1370 63600 1370 {lab=_059_}
N 63080 100 63080 90 {lab=_059_}
N 63080 100 63280 100 {lab=_059_}
N 63280 100 63280 90 {lab=_059_}
N 63280 90 63320 90 {lab=_059_}
N 63320 90 63320 60 {lab=_059_}
N 63320 60 63600 60 {lab=_059_}
N 62930 1620 15940 1620 {lab=_059_}
N 15940 1620 15940 1370 {lab=_059_}
N 15940 1370 15940 60 {lab=_059_}
N 15940 1370 15960 1370 {lab=_059_}
N 15940 60 15960 60 {lab=_059_}
N 2880 1340 2880 1270 {lab=265.ncki}
N 2880 1270 2880 90 {lab=265.ncki}
N 2880 1270 8680 1270 {lab=265.ncki}
N 8680 1270 8680 60 {lab=265.ncki}
N 8680 1270 8680 1370 {lab=265.ncki}
N 8680 1370 8960 1370 {lab=265.ncki}
N 8680 60 8950 60 {lab=265.ncki}
N 8950 60 8950 -20 {lab=265.ncki}
N 8950 60 8960 60 {lab=265.ncki}
N 8950 -20 46520 -20 {lab=265.ncki}
N 46520 -20 46520 250 {lab=265.ncki}
N 46520 250 46520 1220 {lab=265.ncki}
N 46520 250 46880 250 {lab=265.ncki}
N 46520 1220 46790 1220 {lab=265.ncki}
N 46790 1220 46800 1220 {lab=265.ncki}
N 46790 1220 46790 1180 {lab=265.ncki}
N 46880 250 46880 210 {lab=265.ncki}
N 46880 210 47200 210 {lab=265.ncki}
N 46790 1180 48110 1180 {lab=265.ncki}
N 48110 1180 48200 1180 {lab=265.ncki}
N 48110 1180 48110 210 {lab=265.ncki}
N 48200 1180 48200 1220 {lab=265.ncki}
N 48200 1220 48320 1220 {lab=265.ncki}
N 48110 210 48120 210 {lab=265.ncki}
N 2520 1340 2520 90 {lab=264.ncki}
N 2520 1340 2570 1340 {lab=264.ncki}
N 2570 1340 2570 1490 {lab=264.ncki}
N 2570 1490 8320 1490 {lab=264.ncki}
N 8320 1490 8320 1370 {lab=264.ncki}
N 8320 1370 8590 1370 {lab=264.ncki}
N 8590 1370 8590 60 {lab=264.ncki}
N 8590 1370 8600 1370 {lab=264.ncki}
N 8590 60 8590 -40 {lab=264.ncki}
N 8590 60 8600 60 {lab=264.ncki}
N 8590 -40 44640 -40 {lab=264.ncki}
N 44640 -40 44640 1220 {lab=264.ncki}
N 44640 1220 45470 1220 {lab=264.ncki}
N 45470 1220 45470 1180 {lab=264.ncki}
N 45470 1220 45480 1220 {lab=264.ncki}
N 45470 1180 45860 1180 {lab=264.ncki}
N 45860 1180 45860 250 {lab=264.ncki}
N 45860 1180 46320 1180 {lab=264.ncki}
N 46320 1180 46320 1220 {lab=264.ncki}
N 46320 1220 46440 1220 {lab=264.ncki}
N 45860 250 45860 210 {lab=264.ncki}
N 45860 250 45960 250 {lab=264.ncki}
N 45860 210 45880 210 {lab=264.ncki}
N 45960 250 45960 210 {lab=264.ncki}
N 45960 210 46240 210 {lab=264.ncki}
N 2160 1340 2160 90 {lab=263.ncki}
N 2160 1340 2210 1340 {lab=263.ncki}
N 2210 1340 2210 1500 {lab=263.ncki}
N 2210 1500 7960 1500 {lab=263.ncki}
N 7960 1500 7960 1370 {lab=263.ncki}
N 7960 1500 7960 1630 {lab=263.ncki}
N 7960 1370 8230 1370 {lab=263.ncki}
N 8230 1370 8230 60 {lab=263.ncki}
N 8230 1370 8240 1370 {lab=263.ncki}
N 8230 60 8240 60 {lab=263.ncki}
N 7960 1630 40520 1630 {lab=263.ncki}
N 40520 1630 40520 1220 {lab=263.ncki}
N 40520 1220 40990 1220 {lab=263.ncki}
N 40990 1220 40990 1260 {lab=263.ncki}
N 40990 1220 41000 1220 {lab=263.ncki}
N 40990 1260 41380 1260 {lab=263.ncki}
N 41380 1260 41380 250 {lab=263.ncki}
N 41380 1260 41840 1260 {lab=263.ncki}
N 41840 1260 41840 1220 {lab=263.ncki}
N 41840 1220 41960 1220 {lab=263.ncki}
N 41380 250 41380 210 {lab=263.ncki}
N 41380 250 41480 250 {lab=263.ncki}
N 41380 210 41400 210 {lab=263.ncki}
N 41480 250 41480 210 {lab=263.ncki}
N 41480 210 41760 210 {lab=263.ncki}
N 1800 1340 1850 1340 {lab=262.ncki}
N 1800 1340 1800 90 {lab=262.ncki}
N 1850 1340 1850 1510 {lab=262.ncki}
N 1850 1510 7600 1510 {lab=262.ncki}
N 7600 1510 7600 1370 {lab=262.ncki}
N 7600 1370 7870 1370 {lab=262.ncki}
N 7870 1370 7880 1370 {lab=262.ncki}
N 7870 1370 7870 60 {lab=262.ncki}
N 7870 60 7880 60 {lab=262.ncki}
N 7870 60 7870 -50 {lab=262.ncki}
N 7870 -50 35720 -50 {lab=262.ncki}
N 35720 -50 35720 250 {lab=262.ncki}
N 35720 250 36800 250 {lab=262.ncki}
N 35720 250 35720 1220 {lab=262.ncki}
N 35720 1220 36710 1220 {lab=262.ncki}
N 36710 1220 36720 1220 {lab=262.ncki}
N 36710 1220 36710 1260 {lab=262.ncki}
N 36800 250 36800 210 {lab=262.ncki}
N 36800 210 37120 210 {lab=262.ncki}
N 36710 1260 38030 1260 {lab=262.ncki}
N 38030 1260 38120 1260 {lab=262.ncki}
N 38030 1260 38030 210 {lab=262.ncki}
N 38120 1260 38120 1220 {lab=262.ncki}
N 38120 1220 38240 1220 {lab=262.ncki}
N 38030 210 38040 210 {lab=262.ncki}
N 1440 1340 1490 1340 {lab=261.ncki}
N 1440 1340 1440 90 {lab=261.ncki}
N 1490 1340 1490 1520 {lab=261.ncki}
N 1490 1520 7240 1520 {lab=261.ncki}
N 7240 1520 7240 1370 {lab=261.ncki}
N 7240 1520 7240 1640 {lab=261.ncki}
N 7240 1370 7510 1370 {lab=261.ncki}
N 7510 1370 7520 1370 {lab=261.ncki}
N 7510 1370 7510 60 {lab=261.ncki}
N 7510 60 7520 60 {lab=261.ncki}
N 7240 1640 33640 1640 {lab=261.ncki}
N 33640 1640 33640 1220 {lab=261.ncki}
N 33640 1220 34110 1220 {lab=261.ncki}
N 34110 1220 34120 1220 {lab=261.ncki}
N 34110 1220 34110 1180 {lab=261.ncki}
N 34110 1180 34200 1180 {lab=261.ncki}
N 34200 1180 35430 1180 {lab=261.ncki}
N 34200 1180 34200 210 {lab=261.ncki}
N 34200 210 34520 210 {lab=261.ncki}
N 35430 1180 35520 1180 {lab=261.ncki}
N 35430 1180 35430 210 {lab=261.ncki}
N 35520 1180 35520 1220 {lab=261.ncki}
N 35520 1220 35640 1220 {lab=261.ncki}
N 35430 210 35440 210 {lab=261.ncki}
N 1080 1340 1080 90 {lab=260.ncki}
N 1080 1340 1130 1340 {lab=260.ncki}
N 1130 1340 1130 1530 {lab=260.ncki}
N 1130 1530 6880 1530 {lab=260.ncki}
N 6880 1530 6880 1370 {lab=260.ncki}
N 6880 1370 7150 1370 {lab=260.ncki}
N 7150 1370 7150 60 {lab=260.ncki}
N 7150 1370 7160 1370 {lab=260.ncki}
N 7150 60 7150 0 {lab=260.ncki}
N 7150 60 7160 60 {lab=260.ncki}
N 7150 0 28600 0 {lab=260.ncki}
N 28600 0 28600 250 {lab=260.ncki}
N 28600 250 28960 250 {lab=260.ncki}
N 28600 250 28600 1220 {lab=260.ncki}
N 28600 1220 28870 1220 {lab=260.ncki}
N 28870 1220 28870 1260 {lab=260.ncki}
N 28870 1220 28880 1220 {lab=260.ncki}
N 28960 250 28960 210 {lab=260.ncki}
N 28960 210 29260 210 {lab=260.ncki}
N 29260 210 29260 250 {lab=260.ncki}
N 29260 210 29280 210 {lab=260.ncki}
N 28870 1260 30280 1260 {lab=260.ncki}
N 30280 1260 30280 1220 {lab=260.ncki}
N 30280 1220 30400 1220 {lab=260.ncki}
N 29260 250 29360 250 {lab=260.ncki}
N 29360 250 29360 210 {lab=260.ncki}
N 29360 210 30200 210 {lab=260.ncki}
N 720 1340 720 90 {lab=259.ncki}
N 720 1340 770 1340 {lab=259.ncki}
N 770 1340 770 1460 {lab=259.ncki}
N 770 1460 6490 1460 {lab=259.ncki}
N 6490 1460 6490 1420 {lab=259.ncki}
N 6490 1420 6530 1420 {lab=259.ncki}
N 6530 1420 6530 1370 {lab=259.ncki}
N 6530 1370 6790 1370 {lab=259.ncki}
N 6790 1370 6790 60 {lab=259.ncki}
N 6790 1370 6800 1370 {lab=259.ncki}
N 6790 60 6800 60 {lab=259.ncki}
N 6790 60 6790 -30 {lab=259.ncki}
N 6790 -30 25200 -30 {lab=259.ncki}
N 25200 -30 25200 250 {lab=259.ncki}
N 25200 250 25200 1220 {lab=259.ncki}
N 25200 250 25760 250 {lab=259.ncki}
N 25200 1220 25670 1220 {lab=259.ncki}
N 25670 1220 25670 1260 {lab=259.ncki}
N 25670 1220 25680 1220 {lab=259.ncki}
N 25760 250 25760 210 {lab=259.ncki}
N 25760 210 26080 210 {lab=259.ncki}
N 25670 1260 26990 1260 {lab=259.ncki}
N 26990 1260 26990 210 {lab=259.ncki}
N 26990 1260 27080 1260 {lab=259.ncki}
N 27080 1260 27080 1220 {lab=259.ncki}
N 27080 1220 27200 1220 {lab=259.ncki}
N 26990 210 27000 210 {lab=259.ncki}
N 68520 1340 68520 1310 {lab=_063_}
N 68520 1310 70800 1310 {lab=_063_}
N 68520 1310 68520 90 {lab=_063_}
N 70800 1310 70800 1370 {lab=_063_}
N 70800 1370 71060 1370 {lab=_063_}
N 71060 1370 71070 1370 {lab=_063_}
N 71060 1370 71060 110 {lab=_063_}
N 71070 1370 71070 1450 {lab=_063_}
N 71070 1370 71080 1370 {lab=_063_}
N 71070 1450 71360 1450 {lab=_063_}
N 71360 1450 71360 1370 {lab=_063_}
N 71360 1370 71630 1370 {lab=_063_}
N 71630 1370 71630 1320 {lab=_063_}
N 71630 1370 71640 1370 {lab=_063_}
N 71060 110 71060 60 {lab=_063_}
N 71060 110 71160 110 {lab=_063_}
N 71060 60 71080 60 {lab=_063_}
N 71160 110 71160 60 {lab=_063_}
N 71160 60 71640 60 {lab=_063_}
N 71630 1320 75840 1320 {lab=_063_}
N 75840 1320 75840 1370 {lab=_063_}
N 75840 1370 76110 1370 {lab=_063_}
N 76110 1370 76120 1370 {lab=_063_}
N 76110 1370 76110 1180 {lab=_063_}
N 76110 1180 76400 1180 {lab=_063_}
N 76400 1180 76400 60 {lab=_063_}
N 76400 60 76520 60 {lab=_063_}
N 32680 1340 32680 1220 {lab=_044_}
N 32680 1220 32680 100 {lab=_044_}
N 32680 1220 32970 1220 {lab=_044_}
N 32970 1220 32970 1260 {lab=_044_}
N 32970 1220 33000 1220 {lab=_044_}
N 32970 1260 33290 1260 {lab=_044_}
N 33290 1260 33290 1370 {lab=_044_}
N 33290 1370 33540 1370 {lab=_044_}
N 33540 1370 33540 1320 {lab=_044_}
N 33540 1370 33560 1370 {lab=_044_}
N 32680 100 32680 90 {lab=_044_}
N 32680 100 33080 100 {lab=_044_}
N 33080 100 33080 60 {lab=_044_}
N 33080 60 33190 60 {lab=_044_}
N 33190 60 33190 100 {lab=_044_}
N 33190 60 33200 60 {lab=_044_}
N 33190 100 33280 100 {lab=_044_}
N 33280 100 33280 210 {lab=_044_}
N 33280 210 33560 210 {lab=_044_}
N 33540 1320 38680 1320 {lab=_044_}
N 38680 1320 38680 1370 {lab=_044_}
N 38680 1370 38950 1370 {lab=_044_}
N 38950 1370 38960 1370 {lab=_044_}
N 38950 1370 38950 60 {lab=_044_}
N 38950 60 38960 60 {lab=_044_}
N 76920 1340 76960 1340 {lab=_069_}
N 76920 1340 76920 90 {lab=_069_}
N 76960 1340 76960 1370 {lab=_069_}
N 76960 1370 77230 1370 {lab=_069_}
N 77230 1370 77230 1440 {lab=_069_}
N 77230 1370 77240 1370 {lab=_069_}
N 76920 90 76960 90 {lab=_069_}
N 76960 90 76960 60 {lab=_069_}
N 76960 60 77240 60 {lab=_069_}
N 77230 1440 79960 1440 {lab=_069_}
N 79960 1440 79960 1370 {lab=_069_}
N 79960 1370 80220 1370 {lab=_069_}
N 80220 1370 80230 1370 {lab=_069_}
N 80220 1370 80220 110 {lab=_069_}
N 80230 1370 80240 1370 {lab=_069_}
N 80230 1370 80230 1440 {lab=_069_}
N 80230 1440 80520 1440 {lab=_069_}
N 80520 1440 80520 1370 {lab=_069_}
N 80520 1370 80800 1370 {lab=_069_}
N 80220 110 80320 110 {lab=_069_}
N 80220 110 80220 60 {lab=_069_}
N 80220 60 80240 60 {lab=_069_}
N 80320 110 80320 60 {lab=_069_}
N 80320 60 80800 60 {lab=_069_}
N 71680 1190 71680 110 {lab=_065_}
N 71680 1190 71730 1190 {lab=_065_}
N 71730 1190 71730 1370 {lab=_065_}
N 71730 1370 71730 1650 {lab=_065_}
N 71730 1370 72200 1370 {lab=_065_}
N 71680 110 71880 110 {lab=_065_}
N 71680 110 71680 90 {lab=_065_}
N 71880 110 71880 90 {lab=_065_}
N 71880 90 71920 90 {lab=_065_}
N 71920 90 71920 60 {lab=_065_}
N 71920 60 72200 60 {lab=_065_}
N 71730 1650 16710 1650 {lab=_065_}
N 16710 1650 16710 1370 {lab=_065_}
N 16710 1370 16710 60 {lab=_065_}
N 16710 1370 16720 1370 {lab=_065_}
N 16710 60 16720 60 {lab=_065_}
N 36360 1370 36350 1370 {lab=uo_out_2}
N 36350 1370 36350 1340 {lab=uo_out_2}
N 36350 1340 36040 1340 {lab=uo_out_2}
N 36350 1340 36350 90 {lab=uo_out_2}
N 36040 1340 36040 1300 {lab=uo_out_2}
N 36350 90 36350 60 {lab=uo_out_2}
N 36350 90 36040 90 {lab=uo_out_2}
N 36350 60 36360 60 {lab=uo_out_2}
N 36350 60 36350 -50 {lab=uo_out_2}
N 36040 1300 32070 1300 {lab=uo_out_2}
N 32070 1300 32070 60 {lab=uo_out_2}
N 32070 1300 31670 1300 {lab=uo_out_2}
N 31670 1300 31670 1220 {lab=uo_out_2}
N 31670 1220 31680 1220 {lab=uo_out_2}
N 32070 60 32080 60 {lab=uo_out_2}
N 36350 -50 86160 -50 {lab=uo_out_2}
N 86160 -50 86160 870 {lab=uo_out_2}
N 86160 870 86100 870 {lab=uo_out_2}
N 33760 1370 33750 1370 {lab=uo_out_3}
N 33750 1370 33750 1290 {lab=uo_out_3}
N 33750 1290 38640 1290 {lab=uo_out_3}
N 33750 1290 33750 170 {lab=uo_out_3}
N 33750 170 33550 170 {lab=uo_out_3}
N 33550 170 33550 60 {lab=uo_out_3}
N 33550 60 33560 60 {lab=uo_out_3}
N 38640 1290 38640 1220 {lab=uo_out_3}
N 38640 1290 38640 1340 {lab=uo_out_3}
N 38640 1220 38960 1220 {lab=uo_out_3}
N 38640 1220 38640 100 {lab=uo_out_3}
N 38640 100 38640 90 {lab=uo_out_3}
N 38640 100 39040 100 {lab=uo_out_3}
N 39040 100 39040 60 {lab=uo_out_3}
N 39040 60 39150 60 {lab=uo_out_3}
N 39150 60 39160 60 {lab=uo_out_3}
N 39150 60 39150 -60 {lab=uo_out_3}
N 39150 -60 86170 -60 {lab=uo_out_3}
N 86170 -60 86170 910 {lab=uo_out_3}
N 86170 910 86100 910 {lab=uo_out_3}
N 22560 1190 22560 100 {lab=_056_}
N 22560 100 22760 100 {lab=_056_}
N 22560 100 22560 90 {lab=_056_}
N 22760 100 22760 90 {lab=_056_}
N 22760 90 22800 90 {lab=_056_}
N 22800 90 22800 -70 {lab=_056_}
N 22800 -70 59600 -70 {lab=_056_}
N 59600 -70 59600 110 {lab=_056_}
N 59600 110 59600 1220 {lab=_056_}
N 59600 110 59960 110 {lab=_056_}
N 59600 1220 60230 1220 {lab=_056_}
N 60230 1220 60240 1220 {lab=_056_}
N 60230 1220 60230 1180 {lab=_056_}
N 60230 1180 60880 1180 {lab=_056_}
N 60880 1180 60880 1220 {lab=_056_}
N 60880 1220 61000 1220 {lab=_056_}
N 59960 110 59960 60 {lab=_056_}
N 59960 60 60230 60 {lab=_056_}
N 60230 60 60230 110 {lab=_056_}
N 60230 60 60240 60 {lab=_056_}
N 60230 110 60880 110 {lab=_056_}
N 60880 110 60880 60 {lab=_056_}
N 60880 60 61000 60 {lab=_056_}
N 53560 1370 53550 1370 {lab=uo_out_7}
N 53550 1370 53550 1320 {lab=uo_out_7}
N 53550 1320 53340 1320 {lab=uo_out_7}
N 53550 1320 53550 1220 {lab=uo_out_7}
N 53550 1220 53910 1220 {lab=uo_out_7}
N 53910 1220 53910 1260 {lab=uo_out_7}
N 53910 1220 53920 1220 {lab=uo_out_7}
N 53340 1320 53040 1320 {lab=uo_out_7}
N 53340 1320 53340 170 {lab=uo_out_7}
N 53040 1320 53040 1340 {lab=uo_out_7}
N 53340 170 53440 170 {lab=uo_out_7}
N 53340 170 53340 90 {lab=uo_out_7}
N 53340 90 53340 60 {lab=uo_out_7}
N 53340 90 53040 90 {lab=uo_out_7}
N 53340 60 53360 60 {lab=uo_out_7}
N 53440 170 53440 210 {lab=uo_out_7}
N 53440 210 53920 210 {lab=uo_out_7}
N 53910 1260 55490 1260 {lab=uo_out_7}
N 55490 1260 55490 1460 {lab=uo_out_7}
N 55490 1460 86100 1460 {lab=uo_out_7}
N 86100 1460 86100 1070 {lab=uo_out_7}
N 120 1370 110 1370 {lab=_119_}
N 110 1370 110 1570 {lab=_119_}
N 110 1370 -80 1370 {lab=_119_}
N -80 1370 -80 750 {lab=_119_}
N -80 750 -70 750 {lab=_119_}
N -70 750 -70 210 {lab=_119_}
N -70 750 -60 750 {lab=_119_}
N -70 210 120 210 {lab=_119_}
N 110 1570 16240 1570 {lab=_119_}
N 16240 1570 16240 1450 {lab=_119_}
N 16240 1450 17000 1450 {lab=_119_}
N 16240 1450 16240 1370 {lab=_119_}
N 16240 1370 16240 1300 {lab=_119_}
N 16240 1370 16360 1370 {lab=_119_}
N 16240 1300 15930 1300 {lab=_119_}
N 15930 1300 15930 400 {lab=_119_}
N 15930 400 16040 400 {lab=_119_}
N 15930 400 15930 360 {lab=_119_}
N 15930 360 15960 360 {lab=_119_}
N 17000 1450 17000 1370 {lab=_119_}
N 17000 1370 17120 1370 {lab=_119_}
N 16040 400 16040 360 {lab=_119_}
N 16040 360 16720 360 {lab=_119_}
N 65680 1370 65670 1370 {lab=269.net4}
N 65670 1370 65670 1310 {lab=269.net4}
N 65670 1310 61910 1310 {lab=269.net4}
N 65670 1310 65670 60 {lab=269.net4}
N 65670 60 65680 60 {lab=269.net4}
N 61910 1310 61910 1190 {lab=269.net4}
N 61910 1310 61910 1370 {lab=269.net4}
N 61910 1370 61920 1370 {lab=269.net4}
N 61910 1190 61400 1190 {lab=269.net4}
N 61910 1190 61910 90 {lab=269.net4}
N 61910 90 61600 90 {lab=269.net4}
N 61910 90 61910 60 {lab=269.net4}
N 61910 60 61920 60 {lab=269.net4}
N 61600 90 61600 100 {lab=269.net4}
N 61600 100 61400 100 {lab=269.net4}
N 61400 100 61400 90 {lab=269.net4}
N 78960 1370 78950 1370 {lab=272.net4}
N 78950 1370 78950 60 {lab=272.net4}
N 78950 1370 78950 1450 {lab=272.net4}
N 78950 60 78960 60 {lab=272.net4}
N 78950 1450 75190 1450 {lab=272.net4}
N 75190 1450 75190 1370 {lab=272.net4}
N 75190 1370 75200 1370 {lab=272.net4}
N 75190 1370 75190 1190 {lab=272.net4}
N 75190 1190 74680 1190 {lab=272.net4}
N 75190 1190 75190 90 {lab=272.net4}
N 75190 90 75190 60 {lab=272.net4}
N 75190 90 74880 90 {lab=272.net4}
N 75190 60 75200 60 {lab=272.net4}
N 74880 90 74880 100 {lab=272.net4}
N 74880 100 74680 100 {lab=272.net4}
N 74680 100 74680 90 {lab=272.net4}
N 46440 1370 46430 1370 {lab=264.net4}
N 46430 1370 46430 1310 {lab=264.net4}
N 46430 1310 46430 60 {lab=264.net4}
N 46430 1310 42870 1310 {lab=264.net4}
N 46430 60 46440 60 {lab=264.net4}
N 42870 1310 42870 1370 {lab=264.net4}
N 42870 1310 42870 1190 {lab=264.net4}
N 42870 1370 42880 1370 {lab=264.net4}
N 42870 1190 42870 90 {lab=264.net4}
N 42870 1190 42360 1190 {lab=264.net4}
N 42870 90 42870 60 {lab=264.net4}
N 42870 90 42560 90 {lab=264.net4}
N 42870 60 42880 60 {lab=264.net4}
N 42560 90 42560 100 {lab=264.net4}
N 42560 100 42360 100 {lab=264.net4}
N 42360 100 42360 90 {lab=264.net4}
N 74280 1370 74270 1370 {lab=271.net4}
N 74270 1370 74270 1300 {lab=271.net4}
N 74270 1300 74270 60 {lab=271.net4}
N 74270 1300 70710 1300 {lab=271.net4}
N 74270 60 74280 60 {lab=271.net4}
N 70710 1300 70710 1190 {lab=271.net4}
N 70710 1300 70710 1370 {lab=271.net4}
N 70710 1370 70720 1370 {lab=271.net4}
N 70710 1190 70200 1190 {lab=271.net4}
N 70710 1190 70710 90 {lab=271.net4}
N 70710 90 70400 90 {lab=271.net4}
N 70710 90 70710 60 {lab=271.net4}
N 70710 60 70720 60 {lab=271.net4}
N 70400 90 70400 100 {lab=271.net4}
N 70400 100 70200 100 {lab=271.net4}
N 70200 100 70200 90 {lab=271.net4}
N 83440 1370 83430 1370 {lab=273.net4}
N 83430 1370 83430 60 {lab=273.net4}
N 83430 1370 83430 1450 {lab=273.net4}
N 83430 60 83440 60 {lab=273.net4}
N 83430 1450 79870 1450 {lab=273.net4}
N 79870 1450 79870 1370 {lab=273.net4}
N 79870 1370 79870 1190 {lab=273.net4}
N 79870 1370 79880 1370 {lab=273.net4}
N 79870 1190 79360 1190 {lab=273.net4}
N 79870 1190 79870 90 {lab=273.net4}
N 79870 90 79560 90 {lab=273.net4}
N 79870 90 79870 60 {lab=273.net4}
N 79870 60 79880 60 {lab=273.net4}
N 79560 90 79560 100 {lab=273.net4}
N 79560 100 79360 100 {lab=273.net4}
N 79360 100 79360 90 {lab=273.net4}
N 69800 1370 69790 1370 {lab=270.net4}
N 69790 1370 69790 1320 {lab=270.net4}
N 69790 1320 66590 1320 {lab=270.net4}
N 69790 1320 69790 60 {lab=270.net4}
N 69790 60 69800 60 {lab=270.net4}
N 66590 1320 66590 1370 {lab=270.net4}
N 66590 1320 66590 1190 {lab=270.net4}
N 66590 1370 66600 1370 {lab=270.net4}
N 66590 1190 66080 1190 {lab=270.net4}
N 66590 1190 66590 90 {lab=270.net4}
N 66590 90 66590 60 {lab=270.net4}
N 66590 90 66280 90 {lab=270.net4}
N 66590 60 66600 60 {lab=270.net4}
N 66280 90 66280 100 {lab=270.net4}
N 66280 100 66080 100 {lab=270.net4}
N 66080 100 66080 90 {lab=270.net4}
N 57640 1370 57630 1370 {lab=267.net4}
N 57630 1370 57630 1320 {lab=267.net4}
N 57630 1320 57630 60 {lab=267.net4}
N 57630 1320 55030 1320 {lab=267.net4}
N 57630 60 57640 60 {lab=267.net4}
N 55030 1320 55030 1190 {lab=267.net4}
N 55030 1320 55030 1370 {lab=267.net4}
N 55030 1370 55040 1370 {lab=267.net4}
N 55030 1190 54520 1190 {lab=267.net4}
N 55030 1190 55030 90 {lab=267.net4}
N 55030 90 54720 90 {lab=267.net4}
N 55030 90 55030 60 {lab=267.net4}
N 55030 60 55040 60 {lab=267.net4}
N 54720 90 54720 100 {lab=267.net4}
N 54720 100 54520 100 {lab=267.net4}
N 54520 100 54520 90 {lab=267.net4}
N 41960 1370 41950 1370 {lab=263.net4}
N 41950 1370 41950 1310 {lab=263.net4}
N 41950 1310 40070 1310 {lab=263.net4}
N 41950 1310 41950 60 {lab=263.net4}
N 41950 60 41960 60 {lab=263.net4}
N 40070 1310 40070 1370 {lab=263.net4}
N 40070 1310 40070 1190 {lab=263.net4}
N 40070 1370 40080 1370 {lab=263.net4}
N 40070 1190 40070 90 {lab=263.net4}
N 40070 1190 39560 1190 {lab=263.net4}
N 40070 90 40070 60 {lab=263.net4}
N 40070 90 39760 90 {lab=263.net4}
N 40070 60 40080 60 {lab=263.net4}
N 39760 90 39760 100 {lab=263.net4}
N 39760 100 39560 100 {lab=263.net4}
N 39560 100 39560 90 {lab=263.net4}
N 27200 1370 27190 1370 {lab=259.net4}
N 27190 1370 27190 1310 {lab=259.net4}
N 27190 1370 27190 1440 {lab=259.net4}
N 27190 1440 27280 1440 {lab=259.net4}
N 27280 1440 27280 1370 {lab=259.net4}
N 27280 1370 27560 1370 {lab=259.net4}
N 27190 1310 26980 1310 {lab=259.net4}
N 27190 1310 27190 100 {lab=259.net4}
N 26980 1310 26980 1190 {lab=259.net4}
N 26980 1190 26480 1190 {lab=259.net4}
N 27190 100 27190 60 {lab=259.net4}
N 27190 100 27280 100 {lab=259.net4}
N 27190 100 26680 100 {lab=259.net4}
N 27190 60 27200 60 {lab=259.net4}
N 27280 100 27280 60 {lab=259.net4}
N 27280 60 27560 60 {lab=259.net4}
N 26680 100 26680 90 {lab=259.net4}
N 26680 100 26480 100 {lab=259.net4}
N 26480 100 26480 90 {lab=259.net4}
N 30400 1370 30390 1370 {lab=260.net4}
N 30390 1370 30390 1180 {lab=260.net4}
N 30390 1370 30390 1440 {lab=260.net4}
N 30390 1440 30480 1440 {lab=260.net4}
N 30480 1440 30480 1370 {lab=260.net4}
N 30480 1370 30760 1370 {lab=260.net4}
N 30390 1180 30390 100 {lab=260.net4}
N 30390 1180 29680 1180 {lab=260.net4}
N 29680 1180 29680 1190 {lab=260.net4}
N 30390 100 30480 100 {lab=260.net4}
N 30390 100 29880 100 {lab=260.net4}
N 30390 100 30390 60 {lab=260.net4}
N 30390 60 30400 60 {lab=260.net4}
N 30480 100 30480 60 {lab=260.net4}
N 30480 60 30760 60 {lab=260.net4}
N 29880 100 29880 90 {lab=260.net4}
N 29880 100 29680 100 {lab=260.net4}
N 29680 100 29680 90 {lab=260.net4}
N 35640 1370 35630 1370 {lab=261.net4}
N 35630 1370 35630 1310 {lab=261.net4}
N 35630 1310 35720 1310 {lab=261.net4}
N 35630 1310 35430 1310 {lab=261.net4}
N 35630 1310 35630 100 {lab=261.net4}
N 35720 1310 35720 1370 {lab=261.net4}
N 35720 1370 36000 1370 {lab=261.net4}
N 35430 1310 35430 1190 {lab=261.net4}
N 35430 1190 34920 1190 {lab=261.net4}
N 35630 100 35730 100 {lab=261.net4}
N 35630 100 35120 100 {lab=261.net4}
N 35630 100 35630 60 {lab=261.net4}
N 35630 60 35640 60 {lab=261.net4}
N 35730 100 35730 60 {lab=261.net4}
N 35730 60 36000 60 {lab=261.net4}
N 35120 100 35120 90 {lab=261.net4}
N 35120 100 34920 100 {lab=261.net4}
N 34920 100 34920 90 {lab=261.net4}
N 38240 1370 38230 1370 {lab=262.net4}
N 38230 1370 38230 1310 {lab=262.net4}
N 38230 1310 38020 1310 {lab=262.net4}
N 38230 1310 38320 1310 {lab=262.net4}
N 38230 1310 38230 100 {lab=262.net4}
N 38320 1310 38320 1370 {lab=262.net4}
N 38320 1370 38600 1370 {lab=262.net4}
N 38020 1310 38020 1190 {lab=262.net4}
N 38020 1190 37520 1190 {lab=262.net4}
N 38230 100 38320 100 {lab=262.net4}
N 38230 100 38230 60 {lab=262.net4}
N 38230 100 37720 100 {lab=262.net4}
N 38230 60 38240 60 {lab=262.net4}
N 38320 100 38320 60 {lab=262.net4}
N 38320 60 38600 60 {lab=262.net4}
N 37720 100 37520 100 {lab=262.net4}
N 37720 100 37720 90 {lab=262.net4}
N 37520 100 37520 90 {lab=262.net4}
N 48320 1370 48310 1370 {lab=265.net4}
N 48310 1370 48310 1320 {lab=265.net4}
N 48310 1320 48400 1320 {lab=265.net4}
N 48310 1320 48110 1320 {lab=265.net4}
N 48310 1320 48310 100 {lab=265.net4}
N 48400 1320 48400 1370 {lab=265.net4}
N 48400 1370 48680 1370 {lab=265.net4}
N 48110 1320 48110 1190 {lab=265.net4}
N 48110 1190 47600 1190 {lab=265.net4}
N 48310 100 48400 100 {lab=265.net4}
N 48310 100 47800 100 {lab=265.net4}
N 48310 100 48310 60 {lab=265.net4}
N 48310 60 48320 60 {lab=265.net4}
N 48400 100 48400 60 {lab=265.net4}
N 48400 60 48680 60 {lab=265.net4}
N 47800 100 47800 90 {lab=265.net4}
N 47800 100 47600 100 {lab=265.net4}
N 47600 100 47600 90 {lab=265.net4}
N 52640 1370 52630 1370 {lab=266.net4}
N 52630 1370 52630 1430 {lab=266.net4}
N 52630 1370 52630 1320 {lab=266.net4}
N 52630 1430 52720 1430 {lab=266.net4}
N 52720 1430 52720 1370 {lab=266.net4}
N 52720 1370 53000 1370 {lab=266.net4}
N 52630 1320 52420 1320 {lab=266.net4}
N 52630 1320 52630 100 {lab=266.net4}
N 52420 1320 52420 1190 {lab=266.net4}
N 52420 1190 51920 1190 {lab=266.net4}
N 52630 100 52630 60 {lab=266.net4}
N 52630 100 52720 100 {lab=266.net4}
N 52630 100 52120 100 {lab=266.net4}
N 52630 60 52640 60 {lab=266.net4}
N 52720 100 52720 60 {lab=266.net4}
N 52720 60 53000 60 {lab=266.net4}
N 52120 100 51920 100 {lab=266.net4}
N 52120 100 52120 90 {lab=266.net4}
N 51920 100 51920 90 {lab=266.net4}
N 59520 1370 59510 1370 {lab=268.net4}
N 59510 1370 59510 1320 {lab=268.net4}
N 59510 1370 59510 1430 {lab=268.net4}
N 59510 1430 59600 1430 {lab=268.net4}
N 59600 1430 59600 1370 {lab=268.net4}
N 59600 1370 59880 1370 {lab=268.net4}
N 59510 1320 59310 1320 {lab=268.net4}
N 59510 1320 59510 100 {lab=268.net4}
N 59310 1320 59310 1190 {lab=268.net4}
N 59310 1190 58800 1190 {lab=268.net4}
N 59510 100 59610 100 {lab=268.net4}
N 59510 100 59000 100 {lab=268.net4}
N 59510 100 59510 60 {lab=268.net4}
N 59510 60 59520 60 {lab=268.net4}
N 59610 100 59610 60 {lab=268.net4}
N 59610 60 59880 60 {lab=268.net4}
N 59000 100 58800 100 {lab=268.net4}
N 59000 100 59000 90 {lab=268.net4}
N 58800 100 58800 90 {lab=268.net4}
N 85320 1370 85310 1370 {lab=274.net4}
N 85310 1370 85310 1330 {lab=274.net4}
N 85310 1330 85400 1330 {lab=274.net4}
N 85310 1330 85110 1330 {lab=274.net4}
N 85310 1330 85310 100 {lab=274.net4}
N 85400 1330 85400 1370 {lab=274.net4}
N 85400 1370 85680 1370 {lab=274.net4}
N 85110 1330 85110 1190 {lab=274.net4}
N 85110 1190 84600 1190 {lab=274.net4}
N 85310 100 85400 100 {lab=274.net4}
N 85310 100 84800 100 {lab=274.net4}
N 85310 100 85310 60 {lab=274.net4}
N 85310 60 85320 60 {lab=274.net4}
N 85400 100 85400 60 {lab=274.net4}
N 85400 60 85680 60 {lab=274.net4}
N 84800 100 84800 90 {lab=274.net4}
N 84800 100 84600 100 {lab=274.net4}
N 84600 100 84600 90 {lab=274.net4}
N 31720 890 31760 890 {lab=177.Z_neg}
N 31720 890 31720 100 {lab=177.Z_neg}
N 31720 100 31920 100 {lab=177.Z_neg}
N 31720 100 31720 90 {lab=177.Z_neg}
N 31920 100 31920 90 {lab=177.Z_neg}
N 31920 100 32120 100 {lab=177.Z_neg}
N 32120 100 32320 100 {lab=177.Z_neg}
N 32120 100 32120 90 {lab=177.Z_neg}
N 31760 890 31760 1370 {lab=177.Z_neg}
N 31760 1370 32640 1370 {lab=177.Z_neg}
N 32320 100 32320 90 {lab=177.Z_neg}
N 32320 90 32360 90 {lab=177.Z_neg}
N 32360 90 32360 60 {lab=177.Z_neg}
N 32360 60 32640 60 {lab=177.Z_neg}
N 67560 890 67560 870 {lab=206.Z_neg}
N 67560 870 67620 870 {lab=206.Z_neg}
N 67560 870 67560 100 {lab=206.Z_neg}
N 67560 100 67560 90 {lab=206.Z_neg}
N 67560 100 67760 100 {lab=206.Z_neg}
N 67760 100 67760 90 {lab=206.Z_neg}
N 67760 100 67960 100 {lab=206.Z_neg}
N 67960 100 68160 100 {lab=206.Z_neg}
N 67960 100 67960 90 {lab=206.Z_neg}
N 67620 870 67620 1370 {lab=206.Z_neg}
N 67620 1370 68480 1370 {lab=206.Z_neg}
N 68160 100 68160 90 {lab=206.Z_neg}
N 68160 90 68200 90 {lab=206.Z_neg}
N 68200 90 68200 60 {lab=206.Z_neg}
N 68200 60 68480 60 {lab=206.Z_neg}
N 12240 1340 12280 1340 {lab=274.cki}
N 12240 1340 12240 90 {lab=274.cki}
N 12280 1340 12280 1660 {lab=274.cki}
N 12280 1660 83890 1660 {lab=274.cki}
N 83890 1660 83890 1260 {lab=274.cki}
N 83890 1260 83890 1070 {lab=274.cki}
N 83890 1260 84650 1260 {lab=274.cki}
N 83890 1070 84000 1070 {lab=274.cki}
N 83890 1070 83790 1070 {lab=274.cki}
N 83790 1070 83790 210 {lab=274.cki}
N 83790 210 83800 210 {lab=274.cki}
N 84650 1260 84650 1220 {lab=274.cki}
N 84650 1220 85100 1220 {lab=274.cki}
N 85100 1220 85120 1220 {lab=274.cki}
N 85100 1220 85100 1170 {lab=274.cki}
N 85100 1170 85200 1170 {lab=274.cki}
N 85200 1170 85200 210 {lab=274.cki}
N 85200 210 85320 210 {lab=274.cki}
N 11880 1340 11880 90 {lab=273.cki}
N 11880 1340 11930 1340 {lab=273.cki}
N 11930 1340 11930 1670 {lab=273.cki}
N 11930 1670 81650 1670 {lab=273.cki}
N 81650 1670 81650 1070 {lab=273.cki}
N 81650 1070 82470 1070 {lab=273.cki}
N 82470 1070 82670 1070 {lab=273.cki}
N 82470 1070 82470 260 {lab=273.cki}
N 82670 1070 82670 1110 {lab=273.cki}
N 82670 1070 82680 1070 {lab=273.cki}
N 82670 1110 82760 1110 {lab=273.cki}
N 82760 1110 82760 1220 {lab=273.cki}
N 82760 1220 83240 1220 {lab=273.cki}
N 82470 260 82470 210 {lab=273.cki}
N 82470 260 83320 260 {lab=273.cki}
N 82470 210 82480 210 {lab=273.cki}
N 83320 260 83320 210 {lab=273.cki}
N 83320 210 83440 210 {lab=273.cki}
N 11520 1340 11570 1340 {lab=272.cki}
N 11520 1340 11520 90 {lab=272.cki}
N 11570 1340 11570 1680 {lab=272.cki}
N 11570 1680 77650 1680 {lab=272.cki}
N 77650 1680 77650 1070 {lab=272.cki}
N 77650 1070 77990 1070 {lab=272.cki}
N 77990 1070 78190 1070 {lab=272.cki}
N 77990 1070 77990 260 {lab=272.cki}
N 78190 1070 78200 1070 {lab=272.cki}
N 78190 1070 78190 1110 {lab=272.cki}
N 78190 1110 78280 1110 {lab=272.cki}
N 78280 1110 78280 1220 {lab=272.cki}
N 78280 1220 78760 1220 {lab=272.cki}
N 77990 260 78840 260 {lab=272.cki}
N 77990 260 77990 210 {lab=272.cki}
N 77990 210 78000 210 {lab=272.cki}
N 78840 260 78840 210 {lab=272.cki}
N 78840 210 78960 210 {lab=272.cki}
N 11160 1340 11160 90 {lab=271.cki}
N 11160 90 11200 90 {lab=271.cki}
N 11200 90 11200 -80 {lab=271.cki}
N 11200 -80 72480 -80 {lab=271.cki}
N 72480 -80 72480 250 {lab=271.cki}
N 72480 250 72480 1070 {lab=271.cki}
N 72480 250 72840 250 {lab=271.cki}
N 72480 1070 73510 1070 {lab=271.cki}
N 73510 1070 73520 1070 {lab=271.cki}
N 73510 1070 73510 1110 {lab=271.cki}
N 73510 1110 73610 1110 {lab=271.cki}
N 73610 1110 73610 1220 {lab=271.cki}
N 73610 1220 74080 1220 {lab=271.cki}
N 72840 250 72840 210 {lab=271.cki}
N 72840 210 73310 210 {lab=271.cki}
N 73310 210 73320 210 {lab=271.cki}
N 73310 210 73310 170 {lab=271.cki}
N 73310 170 74160 170 {lab=271.cki}
N 74160 170 74160 210 {lab=271.cki}
N 74160 210 74280 210 {lab=271.cki}
N 10800 1340 10800 90 {lab=270.cki}
N 10800 90 10840 90 {lab=270.cki}
N 10840 90 10840 -90 {lab=270.cki}
N 10840 -90 68560 -90 {lab=270.cki}
N 68560 -90 68560 210 {lab=270.cki}
N 68560 210 68560 1070 {lab=270.cki}
N 68560 210 68830 210 {lab=270.cki}
N 68560 1070 69030 1070 {lab=270.cki}
N 69030 1070 69040 1070 {lab=270.cki}
N 69030 1070 69030 1110 {lab=270.cki}
N 69030 1110 69120 1110 {lab=270.cki}
N 69120 1110 69120 1220 {lab=270.cki}
N 69120 1220 69600 1220 {lab=270.cki}
N 68830 210 68840 210 {lab=270.cki}
N 68830 210 68830 170 {lab=270.cki}
N 68830 170 69680 170 {lab=270.cki}
N 69680 170 69680 210 {lab=270.cki}
N 69680 210 69800 210 {lab=270.cki}
N 25160 1190 25360 1190 {lab=_000_}
N 25160 1190 25160 260 {lab=_000_}
N 25360 1190 25360 1340 {lab=_000_}
N 25360 1340 25400 1340 {lab=_000_}
N 25160 260 25160 240 {lab=_000_}
N 25160 260 25360 260 {lab=_000_}
N 25360 260 25360 240 {lab=_000_}
N 25400 1340 25400 1500 {lab=_000_}
N 25400 1500 40530 1500 {lab=_000_}
N 40530 1500 40530 1630 {lab=_000_}
N 40530 1630 83530 1630 {lab=_000_}
N 83530 1630 83530 1370 {lab=_000_}
N 83530 1370 83780 1370 {lab=_000_}
N 83780 1370 83780 60 {lab=_000_}
N 83780 1370 83800 1370 {lab=_000_}
N 83780 60 83800 60 {lab=_000_}
N 10440 1340 10440 90 {lab=269.cki}
N 10440 90 10480 90 {lab=269.cki}
N 10480 90 10480 -100 {lab=269.cki}
N 10480 -100 63880 -100 {lab=269.cki}
N 63880 -100 63880 250 {lab=269.cki}
N 63880 250 63880 1070 {lab=269.cki}
N 63880 250 64240 250 {lab=269.cki}
N 63880 1070 64910 1070 {lab=269.cki}
N 64910 1070 64920 1070 {lab=269.cki}
N 64910 1070 64910 1110 {lab=269.cki}
N 64910 1110 65010 1110 {lab=269.cki}
N 65010 1110 65010 1220 {lab=269.cki}
N 65010 1220 65480 1220 {lab=269.cki}
N 64240 250 64240 210 {lab=269.cki}
N 64240 210 64710 210 {lab=269.cki}
N 64710 210 64710 170 {lab=269.cki}
N 64710 210 64720 210 {lab=269.cki}
N 64710 170 65560 170 {lab=269.cki}
N 65560 170 65560 210 {lab=269.cki}
N 65560 210 65680 210 {lab=269.cki}
N 24600 1190 24600 1160 {lab=_068_}
N 24600 1160 24800 1160 {lab=_068_}
N 24600 1160 24600 240 {lab=_068_}
N 24800 1160 24800 1190 {lab=_068_}
N 24800 1190 24840 1190 {lab=_068_}
N 24600 240 24800 240 {lab=_068_}
N 24800 240 24800 90 {lab=_068_}
N 24840 1190 24840 1690 {lab=_068_}
N 24840 1690 75640 1690 {lab=_068_}
N 75640 1690 75640 1370 {lab=_068_}
N 75640 1370 75650 1370 {lab=_068_}
N 75650 1370 75760 1370 {lab=_068_}
N 75650 1370 75650 170 {lab=_068_}
N 75650 170 75550 170 {lab=_068_}
N 75550 170 75550 60 {lab=_068_}
N 75550 60 75560 60 {lab=_068_}
N 10080 1340 10080 90 {lab=268.cki}
N 10080 90 10120 90 {lab=268.cki}
N 10120 90 10120 -110 {lab=268.cki}
N 10120 -110 57720 -110 {lab=268.cki}
N 57720 -110 57720 210 {lab=268.cki}
N 57720 210 58000 210 {lab=268.cki}
N 57720 210 57720 1070 {lab=268.cki}
N 57720 1070 58190 1070 {lab=268.cki}
N 58190 1070 58190 1110 {lab=268.cki}
N 58190 1070 58200 1070 {lab=268.cki}
N 58190 1110 58840 1110 {lab=268.cki}
N 58840 1110 58840 1220 {lab=268.cki}
N 58840 1220 59300 1220 {lab=268.cki}
N 59300 1220 59320 1220 {lab=268.cki}
N 59300 1220 59300 1160 {lab=268.cki}
N 59300 1160 59400 1160 {lab=268.cki}
N 59400 1160 59400 210 {lab=268.cki}
N 59400 210 59520 210 {lab=268.cki}
N 9720 1340 9720 90 {lab=267.cki}
N 9720 90 9760 90 {lab=267.cki}
N 9760 90 9760 -120 {lab=267.cki}
N 9760 -120 56040 -120 {lab=267.cki}
N 56040 -120 56040 210 {lab=267.cki}
N 56040 210 56670 210 {lab=267.cki}
N 56040 210 56040 1070 {lab=267.cki}
N 56040 1070 56870 1070 {lab=267.cki}
N 56870 1070 56880 1070 {lab=267.cki}
N 56870 1070 56870 1110 {lab=267.cki}
N 56870 1110 56960 1110 {lab=267.cki}
N 56960 1110 56960 1220 {lab=267.cki}
N 56960 1220 57440 1220 {lab=267.cki}
N 56670 210 56680 210 {lab=267.cki}
N 56670 210 56670 170 {lab=267.cki}
N 56670 170 57520 170 {lab=267.cki}
N 57520 170 57520 210 {lab=267.cki}
N 57520 210 57640 210 {lab=267.cki}
N 9360 1340 9360 90 {lab=266.cki}
N 9360 90 9410 90 {lab=266.cki}
N 9410 90 9410 -130 {lab=266.cki}
N 9410 -130 50850 -130 {lab=266.cki}
N 50850 -130 50850 210 {lab=266.cki}
N 50850 210 51120 210 {lab=266.cki}
N 50850 210 50850 1070 {lab=266.cki}
N 50850 1070 51310 1070 {lab=266.cki}
N 51310 1070 51310 1110 {lab=266.cki}
N 51310 1070 51320 1070 {lab=266.cki}
N 51310 1110 51960 1110 {lab=266.cki}
N 51960 1110 51960 1220 {lab=266.cki}
N 51960 1220 52410 1220 {lab=266.cki}
N 52410 1220 52440 1220 {lab=266.cki}
N 52410 1220 52410 1180 {lab=266.cki}
N 52410 1180 52520 1180 {lab=266.cki}
N 52520 1180 52520 210 {lab=266.cki}
N 52520 210 52640 210 {lab=266.cki}
N 24040 1190 24040 1160 {lab=_062_}
N 24040 1160 24240 1160 {lab=_062_}
N 24040 1160 24040 240 {lab=_062_}
N 24240 1160 24240 1190 {lab=_062_}
N 24240 1190 24290 1190 {lab=_062_}
N 24040 240 24240 240 {lab=_062_}
N 24240 240 24240 90 {lab=_062_}
N 24290 1190 24290 1700 {lab=_062_}
N 24290 1700 67040 1700 {lab=_062_}
N 67040 1700 67040 1370 {lab=_062_}
N 67040 1370 67050 1370 {lab=_062_}
N 67050 1370 67160 1370 {lab=_062_}
N 67050 1370 67050 170 {lab=_062_}
N 67050 170 66950 170 {lab=_062_}
N 66950 170 66950 60 {lab=_062_}
N 66950 60 66960 60 {lab=_062_}
N 9000 1340 9000 90 {lab=265.cki}
N 9000 90 9040 90 {lab=265.cki}
N 9040 90 9040 -140 {lab=265.cki}
N 9040 -140 46530 -140 {lab=265.cki}
N 46530 -140 46530 210 {lab=265.cki}
N 46530 210 46530 1070 {lab=265.cki}
N 46530 210 46800 210 {lab=265.cki}
N 46530 1070 46990 1070 {lab=265.cki}
N 46990 1070 47000 1070 {lab=265.cki}
N 46990 1070 46990 1110 {lab=265.cki}
N 46990 1110 47640 1110 {lab=265.cki}
N 47640 1110 47640 1220 {lab=265.cki}
N 47640 1220 48100 1220 {lab=265.cki}
N 48100 1220 48100 1170 {lab=265.cki}
N 48100 1220 48120 1220 {lab=265.cki}
N 48100 1170 48200 1170 {lab=265.cki}
N 48200 1170 48200 210 {lab=265.cki}
N 48200 210 48320 210 {lab=265.cki}
N 60840 1190 60890 1190 {lab=_057_}
N 60890 1190 60890 1710 {lab=_057_}
N 60890 1190 60890 1180 {lab=_057_}
N 60890 1180 61040 1180 {lab=_057_}
N 60890 1180 60890 180 {lab=_057_}
N 61040 1180 61040 1190 {lab=_057_}
N 60890 180 60840 180 {lab=_057_}
N 60840 180 60840 90 {lab=_057_}
N 60890 1710 23070 1710 {lab=_057_}
N 23070 1710 23070 1370 {lab=_057_}
N 23070 1370 23080 1370 {lab=_057_}
N 23070 1370 23070 1330 {lab=_057_}
N 23070 1330 23170 1330 {lab=_057_}
N 23170 1330 23170 60 {lab=_057_}
N 23170 60 23280 60 {lab=_057_}
N 8640 1340 8640 90 {lab=264.cki}
N 8640 90 8690 90 {lab=264.cki}
N 8690 90 8690 -150 {lab=264.cki}
N 8690 -150 44650 -150 {lab=264.cki}
N 44650 -150 44650 210 {lab=264.cki}
N 44650 210 44650 1070 {lab=264.cki}
N 44650 210 45470 210 {lab=264.cki}
N 44650 1070 45670 1070 {lab=264.cki}
N 45670 1070 45670 1110 {lab=264.cki}
N 45670 1070 45680 1070 {lab=264.cki}
N 45670 1110 45760 1110 {lab=264.cki}
N 45760 1110 45760 1220 {lab=264.cki}
N 45760 1220 46240 1220 {lab=264.cki}
N 45470 210 45470 170 {lab=264.cki}
N 45470 210 45480 210 {lab=264.cki}
N 45470 170 46320 170 {lab=264.cki}
N 46320 170 46320 210 {lab=264.cki}
N 46320 210 46440 210 {lab=264.cki}
N 8280 1340 8280 90 {lab=263.cki}
N 8280 90 8320 90 {lab=263.cki}
N 8320 90 8320 -60 {lab=263.cki}
N 8320 -60 39050 -60 {lab=263.cki}
N 39050 -60 39050 1070 {lab=263.cki}
N 39050 1070 40990 1070 {lab=263.cki}
N 40990 1070 41190 1070 {lab=263.cki}
N 40990 1070 40990 260 {lab=263.cki}
N 41190 1070 41190 1110 {lab=263.cki}
N 41190 1070 41200 1070 {lab=263.cki}
N 41190 1110 41290 1110 {lab=263.cki}
N 41290 1110 41290 1220 {lab=263.cki}
N 41290 1220 41760 1220 {lab=263.cki}
N 40990 260 40990 210 {lab=263.cki}
N 40990 260 41840 260 {lab=263.cki}
N 40990 210 41000 210 {lab=263.cki}
N 41840 260 41840 210 {lab=263.cki}
N 41840 210 41960 210 {lab=263.cki}
N 53960 1340 53960 1320 {lab=_055_}
N 53960 1320 53910 1320 {lab=_055_}
N 53960 1320 53960 1250 {lab=_055_}
N 53960 1250 54010 1250 {lab=_055_}
N 54010 1250 54010 250 {lab=_055_}
N 54010 250 54160 250 {lab=_055_}
N 54010 250 54010 240 {lab=_055_}
N 54010 240 53960 240 {lab=_055_}
N 54160 250 54160 240 {lab=_055_}
N 53910 1320 53910 1720 {lab=_055_}
N 53910 1720 21950 1720 {lab=_055_}
N 21950 1720 21950 1370 {lab=_055_}
N 21950 1370 21960 1370 {lab=_055_}
N 21950 1370 21950 60 {lab=_055_}
N 21950 60 21960 60 {lab=_055_}
N 7920 1340 7920 90 {lab=262.cki}
N 7920 1340 7970 1340 {lab=262.cki}
N 7970 1340 7970 1730 {lab=262.cki}
N 7970 1730 36440 1730 {lab=262.cki}
N 36440 1730 36440 1070 {lab=262.cki}
N 36440 1070 36710 1070 {lab=262.cki}
N 36710 1070 36910 1070 {lab=262.cki}
N 36710 1070 36710 210 {lab=262.cki}
N 36910 1070 36910 1110 {lab=262.cki}
N 36910 1070 36920 1070 {lab=262.cki}
N 36710 210 36720 210 {lab=262.cki}
N 36910 1110 37560 1110 {lab=262.cki}
N 37560 1110 37560 1220 {lab=262.cki}
N 37560 1220 38010 1220 {lab=262.cki}
N 38010 1220 38010 1180 {lab=262.cki}
N 38010 1220 38040 1220 {lab=262.cki}
N 38010 1180 38120 1180 {lab=262.cki}
N 38120 1180 38120 210 {lab=262.cki}
N 38120 210 38240 210 {lab=262.cki}
N 50600 1340 50600 1310 {lab=_054_}
N 50600 1310 50540 1310 {lab=_054_}
N 50600 1310 50600 1250 {lab=_054_}
N 50600 1250 50650 1250 {lab=_054_}
N 50650 1250 50650 250 {lab=_054_}
N 50650 250 50800 250 {lab=_054_}
N 50650 250 50650 240 {lab=_054_}
N 50650 240 50600 240 {lab=_054_}
N 50800 250 50800 240 {lab=_054_}
N 50540 1310 50540 1740 {lab=_054_}
N 50540 1740 21390 1740 {lab=_054_}
N 21390 1740 21390 1370 {lab=_054_}
N 21390 1370 21400 1370 {lab=_054_}
N 21390 1370 21380 1370 {lab=_054_}
N 21380 1370 21380 60 {lab=_054_}
N 21380 60 21400 60 {lab=_054_}
N 7560 1340 7560 90 {lab=261.cki}
N 7560 1340 7610 1340 {lab=261.cki}
N 7610 1340 7610 1750 {lab=261.cki}
N 7610 1750 34210 1750 {lab=261.cki}
N 34210 1750 34210 1260 {lab=261.cki}
N 34210 1260 34960 1260 {lab=261.cki}
N 34210 1260 34210 1070 {lab=261.cki}
N 34210 1070 34110 1070 {lab=261.cki}
N 34210 1070 34320 1070 {lab=261.cki}
N 34110 1070 34110 210 {lab=261.cki}
N 34110 210 34120 210 {lab=261.cki}
N 34960 1260 34960 1220 {lab=261.cki}
N 34960 1220 35420 1220 {lab=261.cki}
N 35420 1220 35420 1160 {lab=261.cki}
N 35420 1220 35440 1220 {lab=261.cki}
N 35420 1160 35520 1160 {lab=261.cki}
N 35520 1160 35520 210 {lab=261.cki}
N 35520 210 35640 210 {lab=261.cki}
N 44040 1190 44040 260 {lab=_051_}
N 44040 1190 44240 1190 {lab=_051_}
N 44240 1190 44240 1280 {lab=_051_}
N 44240 1280 33740 1280 {lab=_051_}
N 44240 1280 44240 1340 {lab=_051_}
N 44040 260 44240 260 {lab=_051_}
N 44040 260 44040 240 {lab=_051_}
N 44240 260 44240 240 {lab=_051_}
N 33740 1280 33740 1290 {lab=_051_}
N 33740 1290 20820 1290 {lab=_051_}
N 20820 1290 20820 60 {lab=_051_}
N 20820 1290 20820 1370 {lab=_051_}
N 20820 1370 20840 1370 {lab=_051_}
N 20820 60 20840 60 {lab=_051_}
N 7200 1340 7200 90 {lab=260.cki}
N 7200 90 7240 90 {lab=260.cki}
N 7240 90 7240 -70 {lab=260.cki}
N 7240 -70 22610 -70 {lab=260.cki}
N 22610 -70 22610 110 {lab=260.cki}
N 22610 110 27080 110 {lab=260.cki}
N 27080 110 27080 970 {lab=260.cki}
N 27080 970 28000 970 {lab=260.cki}
N 28000 970 28000 1070 {lab=260.cki}
N 28000 1070 28870 1070 {lab=260.cki}
N 28870 1070 28870 210 {lab=260.cki}
N 28870 1070 29070 1070 {lab=260.cki}
N 29070 1070 29080 1070 {lab=260.cki}
N 29070 1070 29070 1110 {lab=260.cki}
N 28870 210 28880 210 {lab=260.cki}
N 29070 1110 29720 1110 {lab=260.cki}
N 29720 1110 29720 1220 {lab=260.cki}
N 29720 1220 30190 1220 {lab=260.cki}
N 30190 1220 30190 1160 {lab=260.cki}
N 30190 1220 30200 1220 {lab=260.cki}
N 30190 1160 30280 1160 {lab=260.cki}
N 30280 1160 30280 210 {lab=260.cki}
N 30280 210 30400 210 {lab=260.cki}
N 6840 1340 6840 1030 {lab=259.cki}
N 6840 1030 14160 1030 {lab=259.cki}
N 6840 1030 6840 90 {lab=259.cki}
N 14160 1030 14160 1070 {lab=259.cki}
N 14160 1070 25670 1070 {lab=259.cki}
N 25670 1070 25670 210 {lab=259.cki}
N 25670 1070 25870 1070 {lab=259.cki}
N 25870 1070 25880 1070 {lab=259.cki}
N 25870 1070 25870 1110 {lab=259.cki}
N 25670 210 25680 210 {lab=259.cki}
N 25870 1110 26520 1110 {lab=259.cki}
N 26520 1110 26520 1220 {lab=259.cki}
N 26520 1220 26970 1220 {lab=259.cki}
N 26970 1220 27000 1220 {lab=259.cki}
N 26970 1220 26970 1180 {lab=259.cki}
N 26970 1180 27090 1180 {lab=259.cki}
N 27090 1180 27090 210 {lab=259.cki}
N 27090 210 27200 210 {lab=259.cki}
N 20320 1190 20320 1160 {lab=_049_}
N 20320 1160 20520 1160 {lab=_049_}
N 20320 1160 20320 240 {lab=_049_}
N 20520 1160 20520 1150 {lab=_049_}
N 20520 1160 20520 1190 {lab=_049_}
N 20320 240 20520 240 {lab=_049_}
N 20520 240 20520 90 {lab=_049_}
N 20520 1150 33650 1150 {lab=_049_}
N 33650 1150 33650 1270 {lab=_049_}
N 33650 1270 40410 1270 {lab=_049_}
N 40410 1270 40530 1270 {lab=_049_}
N 40410 1270 40410 60 {lab=_049_}
N 40530 1270 40530 1370 {lab=_049_}
N 40530 1370 40640 1370 {lab=_049_}
N 40410 60 40440 60 {lab=_049_}
N 19560 1340 19560 1330 {lab=_017_}
N 19560 1330 19760 1330 {lab=_017_}
N 19560 1330 19560 390 {lab=_017_}
N 19760 1330 19760 1320 {lab=_017_}
N 19760 1330 19760 1340 {lab=_017_}
N 19760 1320 19900 1320 {lab=_017_}
N 19900 1320 19900 1760 {lab=_017_}
N 19900 1320 19960 1320 {lab=_017_}
N 19960 1320 19960 1340 {lab=_017_}
N 19900 1760 36450 1760 {lab=_017_}
N 36450 1760 36450 1370 {lab=_017_}
N 36450 1370 36700 1370 {lab=_017_}
N 36700 1370 36720 1370 {lab=_017_}
N 36700 1370 36700 60 {lab=_017_}
N 36700 60 36720 60 {lab=_017_}
N 14880 1340 14920 1340 {lab=_041_}
N 14880 1340 14880 90 {lab=_041_}
N 14920 1340 14920 1370 {lab=_041_}
N 14920 1370 15190 1370 {lab=_041_}
N 15190 1370 15200 1370 {lab=_041_}
N 15190 1370 15190 1490 {lab=_041_}
N 14880 90 14920 90 {lab=_041_}
N 14920 90 14920 60 {lab=_041_}
N 14920 60 15200 60 {lab=_041_}
N 15190 1490 24640 1490 {lab=_041_}
N 24640 1490 24640 1300 {lab=_041_}
N 24640 1300 30480 1300 {lab=_041_}
N 30480 1300 30480 1220 {lab=_041_}
N 30480 1220 31100 1220 {lab=_041_}
N 31100 1220 31120 1220 {lab=_041_}
N 31100 1220 31100 60 {lab=_041_}
N 31100 60 31120 60 {lab=_041_}
N 33040 1190 33040 1180 {lab=_045_}
N 33040 1180 33240 1180 {lab=_045_}
N 33040 1180 33040 1140 {lab=_045_}
N 33240 1180 33240 1190 {lab=_045_}
N 33040 1140 33040 260 {lab=_045_}
N 33040 1140 18790 1140 {lab=_045_}
N 33040 260 33040 240 {lab=_045_}
N 33040 260 33240 260 {lab=_045_}
N 33240 260 33240 240 {lab=_045_}
N 18790 1140 18790 60 {lab=_045_}
N 18790 1140 18580 1140 {lab=_045_}
N 18580 1140 18580 1370 {lab=_045_}
N 18580 1370 18600 1370 {lab=_045_}
N 18790 60 18800 60 {lab=_045_}
N 33600 1190 33600 1130 {lab=_046_}
N 33600 1190 33800 1190 {lab=_046_}
N 33800 1190 33800 1340 {lab=_046_}
N 33600 1130 33600 260 {lab=_046_}
N 33600 1130 19710 1130 {lab=_046_}
N 33600 260 33800 260 {lab=_046_}
N 33600 260 33600 240 {lab=_046_}
N 33800 260 33800 240 {lab=_046_}
N 19710 1130 19710 1370 {lab=_046_}
N 19710 1130 19710 320 {lab=_046_}
N 19710 1370 19720 1370 {lab=_046_}
N 19710 320 19500 320 {lab=_046_}
N 19500 320 19500 210 {lab=_046_}
N 19500 210 19520 210 {lab=_046_}
N 31160 1190 31160 1180 {lab=_043_}
N 31160 1180 31210 1180 {lab=_043_}
N 31160 1180 31160 240 {lab=_043_}
N 31210 1180 31210 1280 {lab=_043_}
N 31210 1180 31360 1180 {lab=_043_}
N 31360 1180 31360 1190 {lab=_043_}
N 31160 240 31360 240 {lab=_043_}
N 31360 240 31360 90 {lab=_043_}
N 31210 1280 27890 1280 {lab=_043_}
N 27890 1280 27890 1260 {lab=_043_}
N 27890 1260 27180 1260 {lab=_043_}
N 27180 1260 27180 1440 {lab=_043_}
N 27180 1440 22590 1440 {lab=_043_}
N 22590 1440 22590 1450 {lab=_043_}
N 22590 1450 18030 1450 {lab=_043_}
N 18030 1450 18030 1370 {lab=_043_}
N 18030 1370 18040 1370 {lab=_043_}
N 18030 1370 18020 1370 {lab=_043_}
N 18020 1370 18020 60 {lab=_043_}
N 18020 60 18040 60 {lab=_043_}
N 15240 1340 15240 1310 {lab=_014_}
N 15240 1310 15240 390 {lab=_014_}
N 15240 1310 15440 1310 {lab=_014_}
N 15440 1310 15440 1340 {lab=_014_}
N 15440 1310 15640 1310 {lab=_014_}
N 15640 1310 15640 1340 {lab=_014_}
N 15640 1340 15680 1340 {lab=_014_}
N 15680 1340 15680 1480 {lab=_014_}
N 15680 1480 24090 1480 {lab=_014_}
N 24090 1480 24090 1330 {lab=_014_}
N 24090 1330 25410 1330 {lab=_014_}
N 25410 1330 25410 1370 {lab=_014_}
N 25410 1370 25660 1370 {lab=_014_}
N 25660 1370 25660 60 {lab=_014_}
N 25660 1370 25680 1370 {lab=_014_}
N 25660 60 25680 60 {lab=_014_}
N 17520 1190 17520 1170 {lab=_074_}
N 17520 1170 17720 1170 {lab=_074_}
N 17520 1170 17520 240 {lab=_074_}
N 17720 1170 17720 1120 {lab=_074_}
N 17720 1170 17720 1190 {lab=_074_}
N 17520 240 17720 240 {lab=_074_}
N 17720 240 17720 90 {lab=_074_}
N 17720 1120 24850 1120 {lab=_074_}
N 24850 1120 24850 60 {lab=_074_}
N 24850 1120 24850 1260 {lab=_074_}
N 24850 1260 25200 1260 {lab=_074_}
N 25200 1260 25200 1370 {lab=_074_}
N 25200 1370 25320 1370 {lab=_074_}
N 24850 60 25120 60 {lab=_074_}
N 65520 1190 65520 1180 {lab=269.net8}
N 65520 1180 65520 1150 {lab=269.net8}
N 65520 1180 65720 1180 {lab=269.net8}
N 65720 1180 65720 1190 {lab=269.net8}
N 65520 1150 61550 1150 {lab=269.net8}
N 65520 1150 65520 250 {lab=269.net8}
N 65520 250 65720 250 {lab=269.net8}
N 65520 250 65520 240 {lab=269.net8}
N 65720 250 65720 240 {lab=269.net8}
N 61550 1150 61340 1150 {lab=269.net8}
N 61550 1150 61550 60 {lab=269.net8}
N 61340 1150 61340 1220 {lab=269.net8}
N 61340 1220 61360 1220 {lab=269.net8}
N 61550 60 61560 60 {lab=269.net8}
N 78800 1190 78800 1180 {lab=272.net8}
N 78800 1180 78800 1160 {lab=272.net8}
N 78800 1180 79000 1180 {lab=272.net8}
N 79000 1180 79000 1190 {lab=272.net8}
N 78800 1160 74830 1160 {lab=272.net8}
N 78800 1160 78800 270 {lab=272.net8}
N 78800 270 78800 240 {lab=272.net8}
N 78800 270 79000 270 {lab=272.net8}
N 79000 270 79000 240 {lab=272.net8}
N 74830 1160 74630 1160 {lab=272.net8}
N 74830 1160 74830 60 {lab=272.net8}
N 74630 1160 74630 1220 {lab=272.net8}
N 74630 1220 74640 1220 {lab=272.net8}
N 74830 60 74840 60 {lab=272.net8}
N 46280 1190 46280 1170 {lab=264.net8}
N 46280 1170 42510 1170 {lab=264.net8}
N 46280 1170 46280 250 {lab=264.net8}
N 46280 1170 46480 1170 {lab=264.net8}
N 46480 1170 46480 1190 {lab=264.net8}
N 46280 250 46480 250 {lab=264.net8}
N 46280 250 46280 240 {lab=264.net8}
N 46480 250 46480 240 {lab=264.net8}
N 42510 1170 42310 1170 {lab=264.net8}
N 42510 1170 42510 60 {lab=264.net8}
N 42310 1170 42310 1220 {lab=264.net8}
N 42310 1220 42320 1220 {lab=264.net8}
N 42510 60 42520 60 {lab=264.net8}
N 74120 1190 74120 1180 {lab=271.net8}
N 74120 1180 74320 1180 {lab=271.net8}
N 74120 1180 74120 1150 {lab=271.net8}
N 74320 1180 74320 1190 {lab=271.net8}
N 74120 1150 70350 1150 {lab=271.net8}
N 74120 1150 74120 250 {lab=271.net8}
N 74120 250 74120 240 {lab=271.net8}
N 74120 250 74320 250 {lab=271.net8}
N 74320 250 74320 240 {lab=271.net8}
N 70350 1150 70150 1150 {lab=271.net8}
N 70350 1150 70350 60 {lab=271.net8}
N 70150 1150 70150 1220 {lab=271.net8}
N 70150 1220 70160 1220 {lab=271.net8}
N 70350 60 70360 60 {lab=271.net8}
N 83280 1190 83280 1180 {lab=273.net8}
N 83280 1180 79510 1180 {lab=273.net8}
N 83280 1180 83280 270 {lab=273.net8}
N 83280 1180 83480 1180 {lab=273.net8}
N 83480 1180 83480 1190 {lab=273.net8}
N 83280 270 83280 240 {lab=273.net8}
N 83280 270 83480 270 {lab=273.net8}
N 83480 270 83480 240 {lab=273.net8}
N 79510 1180 79310 1180 {lab=273.net8}
N 79510 1180 79510 60 {lab=273.net8}
N 79310 1180 79310 1220 {lab=273.net8}
N 79310 1220 79320 1220 {lab=273.net8}
N 79510 60 79520 60 {lab=273.net8}
N 69640 1190 69640 1180 {lab=270.net8}
N 69640 1180 69840 1180 {lab=270.net8}
N 69640 1180 69640 1150 {lab=270.net8}
N 69840 1180 69840 1190 {lab=270.net8}
N 69640 1150 69640 250 {lab=270.net8}
N 69640 1150 66230 1150 {lab=270.net8}
N 69640 250 69640 240 {lab=270.net8}
N 69640 250 69840 250 {lab=270.net8}
N 69840 250 69840 240 {lab=270.net8}
N 66230 1150 66030 1150 {lab=270.net8}
N 66230 1150 66230 60 {lab=270.net8}
N 66030 1150 66030 1220 {lab=270.net8}
N 66030 1220 66040 1220 {lab=270.net8}
N 66230 60 66240 60 {lab=270.net8}
N 57480 1190 57530 1190 {lab=267.net8}
N 57480 1190 57480 1160 {lab=267.net8}
N 57530 1190 57530 1180 {lab=267.net8}
N 57530 1180 57680 1180 {lab=267.net8}
N 57680 1180 57680 1190 {lab=267.net8}
N 57480 1160 54670 1160 {lab=267.net8}
N 57480 1160 57480 250 {lab=267.net8}
N 57480 250 57480 240 {lab=267.net8}
N 57480 250 57680 250 {lab=267.net8}
N 57680 250 57680 240 {lab=267.net8}
N 54670 1160 54670 60 {lab=267.net8}
N 54670 1160 54460 1160 {lab=267.net8}
N 54460 1160 54460 1220 {lab=267.net8}
N 54460 1220 54480 1220 {lab=267.net8}
N 54670 60 54680 60 {lab=267.net8}
N 41800 1190 41800 1180 {lab=263.net8}
N 41800 1180 42000 1180 {lab=263.net8}
N 41800 1180 41800 1160 {lab=263.net8}
N 42000 1180 42000 1190 {lab=263.net8}
N 41800 1160 41800 270 {lab=263.net8}
N 41800 1160 39710 1160 {lab=263.net8}
N 41800 270 41800 240 {lab=263.net8}
N 41800 270 42000 270 {lab=263.net8}
N 42000 270 42000 240 {lab=263.net8}
N 39710 1160 39710 60 {lab=263.net8}
N 39710 1160 39500 1160 {lab=263.net8}
N 39500 1160 39500 1220 {lab=263.net8}
N 39500 1220 39520 1220 {lab=263.net8}
N 39710 60 39720 60 {lab=263.net8}
N 75600 1190 75800 1190 {lab=_027_}
N 75600 1190 75600 260 {lab=_027_}
N 75800 1190 75800 1310 {lab=_027_}
N 75800 1310 75800 1340 {lab=_027_}
N 75800 1310 77320 1310 {lab=_027_}
N 75600 260 75600 240 {lab=_027_}
N 75600 260 75800 260 {lab=_027_}
N 75800 260 75800 240 {lab=_027_}
N 77320 1310 77320 1370 {lab=_027_}
N 77320 1370 77980 1370 {lab=_027_}
N 77980 1370 77980 60 {lab=_027_}
N 77980 1370 78000 1370 {lab=_027_}
N 77980 60 78000 60 {lab=_027_}
N 62320 1190 62320 260 {lab=_058_}
N 62320 1190 62520 1190 {lab=_058_}
N 62520 1190 62520 1300 {lab=_058_}
N 62520 1300 62520 1340 {lab=_058_}
N 62520 1300 64150 1300 {lab=_058_}
N 62320 260 62520 260 {lab=_058_}
N 62320 260 62320 240 {lab=_058_}
N 62520 260 62520 240 {lab=_058_}
N 64150 1300 64240 1300 {lab=_058_}
N 64150 1300 64150 210 {lab=_058_}
N 64240 1300 64240 1370 {lab=_058_}
N 64240 1370 64360 1370 {lab=_058_}
N 64150 210 64160 210 {lab=_058_}
N 13560 1190 13560 270 {lab=_040_}
N 13560 1190 13760 1190 {lab=_040_}
N 13760 1190 13760 1300 {lab=_040_}
N 13760 1300 15180 1300 {lab=_040_}
N 13760 1300 13760 1340 {lab=_040_}
N 13560 270 13760 270 {lab=_040_}
N 13560 270 13560 240 {lab=_040_}
N 13760 270 13760 240 {lab=_040_}
N 15180 1300 15180 210 {lab=_040_}
N 15180 1300 15280 1300 {lab=_040_}
N 15280 1300 15280 1370 {lab=_040_}
N 15280 1370 15400 1370 {lab=_040_}
N 15180 210 15200 210 {lab=_040_}
N 67000 1190 67200 1190 {lab=_025_}
N 67000 1190 67000 260 {lab=_025_}
N 67200 1190 67200 1300 {lab=_025_}
N 67200 1300 67200 1340 {lab=_025_}
N 67200 1300 68560 1300 {lab=_025_}
N 67000 260 67000 240 {lab=_025_}
N 67000 260 67200 260 {lab=_025_}
N 67200 260 67200 240 {lab=_025_}
N 68560 1300 68560 1370 {lab=_025_}
N 68560 1370 68820 1370 {lab=_025_}
N 68820 1370 68820 60 {lab=_025_}
N 68820 1370 68840 1370 {lab=_025_}
N 68820 60 68840 60 {lab=_025_}
N 25720 1190 25720 1030 {lab=259.net1}
N 25720 1190 25760 1190 {lab=259.net1}
N 25720 1030 25920 1030 {lab=259.net1}
N 25720 1030 25720 260 {lab=259.net1}
N 25920 1030 25920 1040 {lab=259.net1}
N 25720 260 26120 260 {lab=259.net1}
N 25720 260 25720 240 {lab=259.net1}
N 26120 260 26120 240 {lab=259.net1}
N 26120 240 26720 240 {lab=259.net1}
N 25760 1190 25760 1310 {lab=259.net1}
N 25760 1310 26520 1310 {lab=259.net1}
N 26520 1310 26520 1370 {lab=259.net1}
N 26520 1370 27000 1370 {lab=259.net1}
N 26720 240 26720 60 {lab=259.net1}
N 26720 60 27000 60 {lab=259.net1}
N 28920 1190 28960 1190 {lab=260.net1}
N 28920 1190 28920 1020 {lab=260.net1}
N 28920 1020 29120 1020 {lab=260.net1}
N 28920 1020 28920 260 {lab=260.net1}
N 29120 1020 29120 1040 {lab=260.net1}
N 28920 260 29320 260 {lab=260.net1}
N 28920 260 28920 240 {lab=260.net1}
N 29320 260 29320 240 {lab=260.net1}
N 29320 260 29920 260 {lab=260.net1}
N 28960 1190 28960 1310 {lab=260.net1}
N 28960 1310 29720 1310 {lab=260.net1}
N 29720 1310 29720 1370 {lab=260.net1}
N 29720 1370 30200 1370 {lab=260.net1}
N 29920 260 29920 60 {lab=260.net1}
N 29920 60 30200 60 {lab=260.net1}
N 34160 1190 34160 1030 {lab=261.net1}
N 34160 1030 34160 250 {lab=261.net1}
N 34160 1030 34360 1030 {lab=261.net1}
N 34360 1030 34360 1040 {lab=261.net1}
N 34360 1040 34970 1040 {lab=261.net1}
N 34160 250 34560 250 {lab=261.net1}
N 34160 250 34160 240 {lab=261.net1}
N 34560 250 34560 240 {lab=261.net1}
N 34560 240 35160 240 {lab=261.net1}
N 34970 1040 34970 1370 {lab=261.net1}
N 34970 1370 35440 1370 {lab=261.net1}
N 35160 240 35160 60 {lab=261.net1}
N 35160 60 35440 60 {lab=261.net1}
N 36760 1190 36760 1030 {lab=262.net1}
N 36760 1030 36760 260 {lab=262.net1}
N 36760 1030 36960 1030 {lab=262.net1}
N 36960 1030 36960 1040 {lab=262.net1}
N 36960 1040 37570 1040 {lab=262.net1}
N 36760 260 37160 260 {lab=262.net1}
N 36760 260 36760 240 {lab=262.net1}
N 37160 260 37160 240 {lab=262.net1}
N 37160 240 37760 240 {lab=262.net1}
N 37570 1040 37570 1370 {lab=262.net1}
N 37570 1370 38040 1370 {lab=262.net1}
N 37760 240 37760 60 {lab=262.net1}
N 37760 60 38040 60 {lab=262.net1}
N 46840 1190 46840 1030 {lab=265.net1}
N 46840 1030 46840 260 {lab=265.net1}
N 46840 1030 47040 1030 {lab=265.net1}
N 47040 1030 47040 1040 {lab=265.net1}
N 47040 1040 47650 1040 {lab=265.net1}
N 46840 260 47240 260 {lab=265.net1}
N 46840 260 46840 240 {lab=265.net1}
N 47240 260 47240 240 {lab=265.net1}
N 47240 240 47840 240 {lab=265.net1}
N 47650 1040 47650 1370 {lab=265.net1}
N 47650 1370 48120 1370 {lab=265.net1}
N 47840 240 47840 60 {lab=265.net1}
N 47840 60 48120 60 {lab=265.net1}
N 51160 1190 51160 1030 {lab=266.net1}
N 51160 1030 51360 1030 {lab=266.net1}
N 51160 1030 51160 260 {lab=266.net1}
N 51360 1030 51360 1040 {lab=266.net1}
N 51360 1040 51970 1040 {lab=266.net1}
N 51160 260 51560 260 {lab=266.net1}
N 51160 260 51160 240 {lab=266.net1}
N 51560 260 51560 240 {lab=266.net1}
N 51560 240 52160 240 {lab=266.net1}
N 51970 1040 51970 1370 {lab=266.net1}
N 51970 1370 52440 1370 {lab=266.net1}
N 52160 240 52160 60 {lab=266.net1}
N 52160 60 52440 60 {lab=266.net1}
N 58040 1190 58040 1030 {lab=268.net1}
N 58040 1030 58240 1030 {lab=268.net1}
N 58040 1030 58040 250 {lab=268.net1}
N 58240 1030 58240 1040 {lab=268.net1}
N 58240 1040 58850 1040 {lab=268.net1}
N 58040 250 58040 240 {lab=268.net1}
N 58040 250 58440 250 {lab=268.net1}
N 58440 250 58440 240 {lab=268.net1}
N 58440 240 59040 240 {lab=268.net1}
N 58850 1040 58850 1370 {lab=268.net1}
N 58850 1370 59320 1370 {lab=268.net1}
N 59040 240 59040 60 {lab=268.net1}
