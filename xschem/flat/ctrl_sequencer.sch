v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {ctrl_sequencer: controller flow box "Sequencer" at transistor level (61 cells)} 0 -230 0 0 0.45 0.45 {}
T {Synthesized from meta_controller.v; every cell opened up. Stage labels are the cell instance names.} 0 -190 0 0 0.26 0.26 {}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29140 1370 0 0 {name=M125_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29140 60 0 0 {name=M125_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1660 1370 0 0 {name=M127_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1660 60 0 0 {name=M127_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32260 1370 0 0 {name=M128_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32260 60 0 0 {name=M128_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33540 1370 0 0 {name=M129_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33540 60 0 0 {name=M129_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35380 1370 0 0 {name=M130_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35380 60 0 0 {name=M130_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27860 1370 0 0 {name=M131_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27860 60 0 0 {name=M131_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12940 1220 0 0 {name=M132_i_2 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12940 1370 0 0 {name=M132_i_3 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13500 1370 0 0 {name=M132_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12940 60 0 0 {name=M132_i_4 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13140 60 0 0 {name=M132_i_5 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13500 60 0 0 {name=M132_i_1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13860 1370 0 0 {name=M133_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13860 1220 0 0 {name=M133_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13860 60 0 0 {name=M133_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14060 60 0 0 {name=M133_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33900 1370 0 0 {name=M134_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34100 1370 0 0 {name=M134_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33900 60 0 0 {name=M134_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33900 210 0 0 {name=M134_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35740 1370 0 0 {name=M141_i_2 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35940 1370 0 0 {name=M141_i_1 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36140 1370 0 0 {name=M141_i_0 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35740 60 0 0 {name=M141_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35740 210 0 0 {name=M141_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35740 360 0 0 {name=M141_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36500 1370 0 0 {name=M142_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36500 1220 0 0 {name=M142_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36500 60 0 0 {name=M142_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36700 60 0 0 {name=M142_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37060 1370 0 0 {name=M143_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37060 1220 0 0 {name=M143_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37260 1370 0 0 {name=M143_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37060 210 0 0 {name=M143_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37260 210 0 0 {name=M143_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37060 60 0 0 {name=M143_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37620 1370 0 0 {name=M144_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37620 1220 0 0 {name=M144_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37620 1070 0 0 {name=M144_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37620 60 0 0 {name=M144_i_5 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37820 60 0 0 {name=M144_i_4 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38020 60 0 0 {name=M144_i_3 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38380 1370 0 0 {name=M145_i_2 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38580 1370 0 0 {name=M145_i_1 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38780 1370 0 0 {name=M145_i_0 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38380 60 0 0 {name=M145_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38380 210 0 0 {name=M145_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38380 360 0 0 {name=M145_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39140 1370 0 0 {name=M147_i_2 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39340 1370 0 0 {name=M147_i_1 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39540 1370 0 0 {name=M147_i_0 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39140 60 0 0 {name=M147_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39140 210 0 0 {name=M147_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39140 360 0 0 {name=M147_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39900 1370 0 0 {name=M148_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39900 1220 0 0 {name=M148_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40100 1370 0 0 {name=M148_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39900 210 0 0 {name=M148_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40100 210 0 0 {name=M148_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39900 60 0 0 {name=M148_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40460 1370 0 0 {name=M149_i_3 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40660 1370 0 0 {name=M149_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40660 1220 0 0 {name=M149_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40460 1220 0 0 {name=M149_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40460 60 0 0 {name=M149_i_7 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40460 210 0 0 {name=M149_i_6 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40660 210 0 0 {name=M149_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40660 60 0 0 {name=M149_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41020 1370 0 0 {name=M150_i_3 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41220 1370 0 0 {name=M150_i_2 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41420 1370 0 0 {name=M150_i_1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41620 1370 0 0 {name=M150_i_0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41020 60 0 0 {name=M150_i_7 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41020 210 0 0 {name=M150_i_6 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41020 360 0 0 {name=M150_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41020 510 0 0 {name=M150_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41980 1370 0 0 {name=M151_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41980 1220 0 0 {name=M151_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41980 60 0 0 {name=M151_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42180 60 0 0 {name=M151_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42540 1370 0 0 {name=M152_i_2 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42740 1370 0 0 {name=M152_i_3 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43100 1370 0 0 {name=M152_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42540 210 0 0 {name=M152_i_4 L=0.5u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42540 60 0 0 {name=M152_i_5 L=0.5u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43100 60 0 0 {name=M152_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14420 1220 0 0 {name=M153_i_2 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14420 1370 0 0 {name=M153_i_3 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14980 1370 0 0 {name=M153_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14420 60 0 0 {name=M153_i_4 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14620 60 0 0 {name=M153_i_5 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14980 60 0 0 {name=M153_i_1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43460 1370 0 0 {name=M155_i_2 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43660 1370 0 0 {name=M155_i_1 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43860 1370 0 0 {name=M155_i_0 L=0.6u W=0.465u nf=1 m=1 ad=2.325e-13 as=2.325e-13 pd=1.93e-06 ps=1.93e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43460 60 0 0 {name=M155_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43460 210 0 0 {name=M155_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43460 360 0 0 {name=M155_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15340 1370 0 0 {name=M157_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15540 1370 0 0 {name=M157_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15340 60 0 0 {name=M157_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15340 210 0 0 {name=M157_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 140 1370 0 0 {name=M158_i_3 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 140 1220 0 0 {name=M158_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 140 1070 0 0 {name=M158_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 140 920 0 0 {name=M158_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 140 60 0 0 {name=M158_i_7 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 340 60 0 0 {name=M158_i_6 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 540 60 0 0 {name=M158_i_5 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 740 60 0 0 {name=M158_i_4 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1100 1370 0 0 {name=M159_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1100 1220 0 0 {name=M159_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1100 60 0 0 {name=M159_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1300 60 0 0 {name=M159_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2020 1370 0 0 {name=M160_i_3 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2220 1370 0 0 {name=M160_i_2 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2420 1370 0 0 {name=M160_i_1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2620 1370 0 0 {name=M160_i_0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2020 60 0 0 {name=M160_i_7 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2020 210 0 0 {name=M160_i_6 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2020 360 0 0 {name=M160_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2020 510 0 0 {name=M160_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44220 1370 0 0 {name=M163_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44420 1370 0 0 {name=M163_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44220 60 0 0 {name=M163_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44220 210 0 0 {name=M163_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44780 1370 0 0 {name=M164_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44780 1220 0 0 {name=M164_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44780 60 0 0 {name=M164_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44980 60 0 0 {name=M164_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45340 1370 0 0 {name=M165_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45340 1220 0 0 {name=M165_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45340 60 0 0 {name=M165_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45540 60 0 0 {name=M165_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15900 1370 0 0 {name=M166_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15900 1220 0 0 {name=M166_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15900 1070 0 0 {name=M166_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15900 60 0 0 {name=M166_i_5 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16100 60 0 0 {name=M166_i_4 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16300 60 0 0 {name=M166_i_3 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45900 1370 0 0 {name=M167_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45900 1220 0 0 {name=M167_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45900 60 0 0 {name=M167_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46100 60 0 0 {name=M167_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46460 1370 0 0 {name=M168_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46460 1220 0 0 {name=M168_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46460 60 0 0 {name=M168_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46660 60 0 0 {name=M168_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16660 1370 0 0 {name=M169_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16660 1220 0 0 {name=M169_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16660 1070 0 0 {name=M169_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16660 60 0 0 {name=M169_i_5 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16860 60 0 0 {name=M169_i_4 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17060 60 0 0 {name=M169_i_3 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47020 1370 0 0 {name=M170_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47020 1220 0 0 {name=M170_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47020 60 0 0 {name=M170_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47220 60 0 0 {name=M170_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47580 1370 0 0 {name=M227_i_3 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47580 1220 0 0 {name=M227_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47580 1070 0 0 {name=M227_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47580 920 0 0 {name=M227_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47580 60 0 0 {name=M227_i_7 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47780 60 0 0 {name=M227_i_6 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47980 60 0 0 {name=M227_i_5 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48180 60 0 0 {name=M227_i_4 L=0.5u W=0.845u nf=1 m=1 ad=4.225e-13 as=4.225e-13 pd=2.69e-06 ps=2.69e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48540 1370 0 0 {name=M228_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48740 1370 0 0 {name=M228_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48540 60 0 0 {name=M228_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48540 210 0 0 {name=M228_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49100 1370 0 0 {name=M229_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49100 1220 0 0 {name=M229_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49100 60 0 0 {name=M229_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49300 60 0 0 {name=M229_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2980 1370 0 0 {name=M230_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3180 1370 0 0 {name=M230_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2980 60 0 0 {name=M230_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2980 210 0 0 {name=M230_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49660 1370 0 0 {name=M231_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49660 1220 0 0 {name=M231_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49660 60 0 0 {name=M231_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49860 60 0 0 {name=M231_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50220 1220 0 0 {name=M232_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50420 1220 0 0 {name=M232_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50220 1370 0 0 {name=M232_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50220 60 0 0 {name=M232_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50220 210 0 0 {name=M232_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50420 60 0 0 {name=M232_i_5 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50780 1220 0 0 {name=M233_i_2 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50780 1370 0 0 {name=M233_i_3 L=0.6u W=0.365u nf=1 m=1 ad=1.825e-13 as=1.825e-13 pd=1.73e-06 ps=1.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51340 1370 0 0 {name=M233_i_0 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50780 60 0 0 {name=M233_i_4 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50980 60 0 0 {name=M233_i_5 L=0.5u W=0.6u nf=1 m=1 ad=3e-13 as=3e-13 pd=2.2e-06 ps=2.2e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51340 60 0 0 {name=M233_i_1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51700 1220 0 0 {name=M234_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51900 1220 0 0 {name=M234_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51700 1370 0 0 {name=M234_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51700 60 0 0 {name=M234_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51700 210 0 0 {name=M234_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51900 60 0 0 {name=M234_i_5 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52260 1220 0 0 {name=M235_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52460 1220 0 0 {name=M235_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52260 1370 0 0 {name=M235_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52260 60 0 0 {name=M235_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52260 210 0 0 {name=M235_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52460 60 0 0 {name=M235_i_5 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52820 1070 0 0 {name=M236_i_2 L=0.6u W=0.38u nf=1 m=1 ad=1.9e-13 as=1.9e-13 pd=1.76e-06 ps=1.76e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52820 1220 0 0 {name=M236_i_3 L=0.6u W=0.38u nf=1 m=1 ad=1.9e-13 as=1.9e-13 pd=1.76e-06 ps=1.76e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52820 1370 0 0 {name=M236_i_4 L=0.6u W=0.38u nf=1 m=1 ad=1.9e-13 as=1.9e-13 pd=1.76e-06 ps=1.76e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53580 1370 0 0 {name=M236_i_0 L=0.6u W=0.775u nf=1 m=1 ad=3.875e-13 as=3.875e-13 pd=2.55e-06 ps=2.55e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52820 60 0 0 {name=M236_i_5 L=0.5u W=0.535u nf=1 m=1 ad=2.675e-13 as=2.675e-13 pd=2.07e-06 ps=2.07e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53020 60 0 0 {name=M236_i_6 L=0.5u W=0.535u nf=1 m=1 ad=2.675e-13 as=2.675e-13 pd=2.07e-06 ps=2.07e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53220 60 0 0 {name=M236_i_7 L=0.5u W=0.535u nf=1 m=1 ad=2.675e-13 as=2.675e-13 pd=2.07e-06 ps=2.07e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53580 60 0 0 {name=M236_i_1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53940 1370 0 0 {name=M237_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54140 1370 0 0 {name=M237_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53940 60 0 0 {name=M237_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53940 210 0 0 {name=M237_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54500 1370 0 0 {name=M238_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54500 1220 0 0 {name=M238_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54500 1070 0 0 {name=M238_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54500 60 0 0 {name=M238_i_5 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54700 60 0 0 {name=M238_i_4 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54900 60 0 0 {name=M238_i_3 L=0.5u W=0.985u nf=1 m=1 ad=4.925e-13 as=4.925e-13 pd=2.97e-06 ps=2.97e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55260 1370 0 0 {name=M239_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55260 1220 0 0 {name=M239_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55260 60 0 0 {name=M239_i_3 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55460 60 0 0 {name=M239_i_2 L=0.5u W=1.13u nf=1 m=1 ad=5.65e-13 as=5.65e-13 pd=3.26e-06 ps=3.26e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55820 1370 0 0 {name=M240_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55820 1220 0 0 {name=M240_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56020 1370 0 0 {name=M240_i_2 L=0.6u W=0.51u nf=1 m=1 ad=2.55e-13 as=2.55e-13 pd=2.02e-06 ps=2.02e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55820 210 0 0 {name=M240_i_4 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56020 210 0 0 {name=M240_i_3 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55820 60 0 0 {name=M240_i_5 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56380 1370 0 0 {name=M241_i_1 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56580 1370 0 0 {name=M241_i_0 L=0.6u W=0.565u nf=1 m=1 ad=2.825e-13 as=2.825e-13 pd=2.13e-06 ps=2.13e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56380 60 0 0 {name=M241_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56380 210 0 0 {name=M241_i_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3540 1370 0 0 {name=M251_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7500 1370 0 0 {name=M251_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17420 1370 0 0 {name=M251_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17420 1220 0 0 {name=M251_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17620 1070 0 0 {name=M251_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17620 1220 0 0 {name=M251_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17620 1370 0 0 {name=M251_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18740 1370 0 0 {name=M251_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18740 1220 0 0 {name=M251_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18940 1220 0 0 {name=M251_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18940 1370 0 0 {name=M251_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18180 1370 0 0 {name=M251_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18180 1220 0 0 {name=M251_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19300 1370 0 0 {name=M251_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3540 60 0 0 {name=M251_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7500 60 0 0 {name=M251_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17420 60 0 0 {name=M251_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17420 210 0 0 {name=M251_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17820 210 0 0 {name=M251_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17620 60 0 0 {name=M251_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17820 60 0 0 {name=M251_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18740 60 0 0 {name=M251_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18740 210 0 0 {name=M251_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18940 210 0 0 {name=M251_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18940 60 0 0 {name=M251_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18180 60 0 0 {name=M251_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18380 60 0 0 {name=M251_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19300 60 0 0 {name=M251_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3900 1370 0 0 {name=M252_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7860 1370 0 0 {name=M252_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19660 1370 0 0 {name=M252_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19660 1220 0 0 {name=M252_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19860 1070 0 0 {name=M252_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19860 1220 0 0 {name=M252_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19860 1370 0 0 {name=M252_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20980 1370 0 0 {name=M252_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20980 1220 0 0 {name=M252_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21180 1220 0 0 {name=M252_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21180 1370 0 0 {name=M252_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20420 1370 0 0 {name=M252_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20420 1220 0 0 {name=M252_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21540 1370 0 0 {name=M252_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3900 60 0 0 {name=M252_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7860 60 0 0 {name=M252_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19660 60 0 0 {name=M252_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19660 210 0 0 {name=M252_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20060 210 0 0 {name=M252_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19860 60 0 0 {name=M252_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20060 60 0 0 {name=M252_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20980 60 0 0 {name=M252_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20980 210 0 0 {name=M252_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21180 210 0 0 {name=M252_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21180 60 0 0 {name=M252_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20420 60 0 0 {name=M252_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20620 60 0 0 {name=M252_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21540 60 0 0 {name=M252_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4260 1370 0 0 {name=M253_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8220 1370 0 0 {name=M253_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12180 1370 0 0 {name=M253_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12180 1220 0 0 {name=M253_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12380 1070 0 0 {name=M253_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12380 1220 0 0 {name=M253_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12380 1370 0 0 {name=M253_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22460 1370 0 0 {name=M253_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22460 1220 0 0 {name=M253_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22660 1220 0 0 {name=M253_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22660 1370 0 0 {name=M253_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21900 1370 0 0 {name=M253_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21900 1220 0 0 {name=M253_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23020 1370 0 0 {name=M253_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4260 60 0 0 {name=M253_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8220 60 0 0 {name=M253_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12180 60 0 0 {name=M253_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12180 210 0 0 {name=M253_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12580 210 0 0 {name=M253_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12380 60 0 0 {name=M253_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12580 60 0 0 {name=M253_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22460 60 0 0 {name=M253_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22460 210 0 0 {name=M253_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22660 210 0 0 {name=M253_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22660 60 0 0 {name=M253_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21900 60 0 0 {name=M253_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22100 60 0 0 {name=M253_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23020 60 0 0 {name=M253_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4620 1370 0 0 {name=M254_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8580 1370 0 0 {name=M254_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23380 1370 0 0 {name=M254_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23380 1220 0 0 {name=M254_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23580 1070 0 0 {name=M254_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23580 1220 0 0 {name=M254_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23580 1370 0 0 {name=M254_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24700 1370 0 0 {name=M254_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24700 1220 0 0 {name=M254_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24900 1220 0 0 {name=M254_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24900 1370 0 0 {name=M254_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24140 1370 0 0 {name=M254_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24140 1220 0 0 {name=M254_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25260 1370 0 0 {name=M254_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4620 60 0 0 {name=M254_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8580 60 0 0 {name=M254_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23380 60 0 0 {name=M254_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23380 210 0 0 {name=M254_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23780 210 0 0 {name=M254_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23580 60 0 0 {name=M254_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23780 60 0 0 {name=M254_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24700 60 0 0 {name=M254_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24700 210 0 0 {name=M254_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24900 210 0 0 {name=M254_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24900 60 0 0 {name=M254_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24140 60 0 0 {name=M254_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24340 60 0 0 {name=M254_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25260 60 0 0 {name=M254_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4980 1370 0 0 {name=M255_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8940 1370 0 0 {name=M255_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25620 1370 0 0 {name=M255_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25620 1220 0 0 {name=M255_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25820 1070 0 0 {name=M255_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25820 1220 0 0 {name=M255_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25820 1370 0 0 {name=M255_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26940 1370 0 0 {name=M255_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26940 1220 0 0 {name=M255_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27140 1220 0 0 {name=M255_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27140 1370 0 0 {name=M255_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26380 1370 0 0 {name=M255_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26380 1220 0 0 {name=M255_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27500 1370 0 0 {name=M255_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4980 60 0 0 {name=M255_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8940 60 0 0 {name=M255_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25620 60 0 0 {name=M255_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25620 210 0 0 {name=M255_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26020 210 0 0 {name=M255_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25820 60 0 0 {name=M255_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26020 60 0 0 {name=M255_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26940 60 0 0 {name=M255_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26940 210 0 0 {name=M255_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27140 210 0 0 {name=M255_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27140 60 0 0 {name=M255_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26380 60 0 0 {name=M255_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26580 60 0 0 {name=M255_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27500 60 0 0 {name=M255_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5340 1370 0 0 {name=M256_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9300 1370 0 0 {name=M256_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56940 1370 0 0 {name=M256_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56940 1220 0 0 {name=M256_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57140 1070 0 0 {name=M256_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57140 1220 0 0 {name=M256_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57140 1370 0 0 {name=M256_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57700 1370 0 0 {name=M256_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57700 1220 0 0 {name=M256_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57900 1220 0 0 {name=M256_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 57900 1370 0 0 {name=M256_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28220 1370 0 0 {name=M256_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28220 1220 0 0 {name=M256_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28780 1370 0 0 {name=M256_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5340 60 0 0 {name=M256_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9300 60 0 0 {name=M256_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56940 60 0 0 {name=M256_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56940 210 0 0 {name=M256_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57340 210 0 0 {name=M256_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57140 60 0 0 {name=M256_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57340 60 0 0 {name=M256_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57700 60 0 0 {name=M256_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57700 210 0 0 {name=M256_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57900 210 0 0 {name=M256_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 57900 60 0 0 {name=M256_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28220 60 0 0 {name=M256_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28420 60 0 0 {name=M256_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28780 60 0 0 {name=M256_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5700 1370 0 0 {name=M257_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9660 1370 0 0 {name=M257_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58260 1370 0 0 {name=M257_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58260 1220 0 0 {name=M257_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58460 1070 0 0 {name=M257_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58460 1220 0 0 {name=M257_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 58460 1370 0 0 {name=M257_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59020 1370 0 0 {name=M257_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59020 1220 0 0 {name=M257_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59220 1220 0 0 {name=M257_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59220 1370 0 0 {name=M257_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29500 1370 0 0 {name=M257_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29500 1220 0 0 {name=M257_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30060 1370 0 0 {name=M257_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5700 60 0 0 {name=M257_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9660 60 0 0 {name=M257_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58260 60 0 0 {name=M257_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58260 210 0 0 {name=M257_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58660 210 0 0 {name=M257_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58460 60 0 0 {name=M257_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 58660 60 0 0 {name=M257_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59020 60 0 0 {name=M257_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59020 210 0 0 {name=M257_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59220 210 0 0 {name=M257_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59220 60 0 0 {name=M257_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29500 60 0 0 {name=M257_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29700 60 0 0 {name=M257_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30060 60 0 0 {name=M257_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6060 1370 0 0 {name=M258_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10020 1370 0 0 {name=M258_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59580 1370 0 0 {name=M258_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59580 1220 0 0 {name=M258_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59780 1070 0 0 {name=M258_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59780 1220 0 0 {name=M258_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 59780 1370 0 0 {name=M258_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60340 1370 0 0 {name=M258_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60340 1220 0 0 {name=M258_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60540 1220 0 0 {name=M258_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60540 1370 0 0 {name=M258_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30420 1370 0 0 {name=M258_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30420 1220 0 0 {name=M258_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30980 1370 0 0 {name=M258_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6060 60 0 0 {name=M258_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10020 60 0 0 {name=M258_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59580 60 0 0 {name=M258_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59580 210 0 0 {name=M258_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59980 210 0 0 {name=M258_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59780 60 0 0 {name=M258_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 59980 60 0 0 {name=M258_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60340 60 0 0 {name=M258_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60340 210 0 0 {name=M258_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60540 210 0 0 {name=M258_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60540 60 0 0 {name=M258_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30420 60 0 0 {name=M258_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30620 60 0 0 {name=M258_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30980 60 0 0 {name=M258_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6420 1370 0 0 {name=M278_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10380 1370 0 0 {name=M278_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60900 1370 0 0 {name=M278_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 60900 1220 0 0 {name=M278_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61100 1070 0 0 {name=M278_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61100 1220 0 0 {name=M278_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61100 1370 0 0 {name=M278_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61660 1370 0 0 {name=M278_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61660 1220 0 0 {name=M278_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61860 1220 0 0 {name=M278_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 61860 1370 0 0 {name=M278_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31340 1370 0 0 {name=M278_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31340 1220 0 0 {name=M278_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31900 1370 0 0 {name=M278_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6420 60 0 0 {name=M278_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10380 60 0 0 {name=M278_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60900 60 0 0 {name=M278_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 60900 210 0 0 {name=M278_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61300 210 0 0 {name=M278_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61100 60 0 0 {name=M278_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61300 60 0 0 {name=M278_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61660 60 0 0 {name=M278_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61660 210 0 0 {name=M278_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61860 210 0 0 {name=M278_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 61860 60 0 0 {name=M278_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31340 60 0 0 {name=M278_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31540 60 0 0 {name=M278_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31900 60 0 0 {name=M278_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6780 1370 0 0 {name=M279_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10740 1370 0 0 {name=M279_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62220 1370 0 0 {name=M279_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62220 1220 0 0 {name=M279_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62420 1070 0 0 {name=M279_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62420 1220 0 0 {name=M279_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62420 1370 0 0 {name=M279_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62980 1370 0 0 {name=M279_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 62980 1220 0 0 {name=M279_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63180 1220 0 0 {name=M279_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63180 1370 0 0 {name=M279_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32620 1370 0 0 {name=M279_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32620 1220 0 0 {name=M279_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33180 1370 0 0 {name=M279_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6780 60 0 0 {name=M279_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10740 60 0 0 {name=M279_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62220 60 0 0 {name=M279_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62220 210 0 0 {name=M279_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62620 210 0 0 {name=M279_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62420 60 0 0 {name=M279_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62620 60 0 0 {name=M279_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62980 60 0 0 {name=M279_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 62980 210 0 0 {name=M279_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63180 210 0 0 {name=M279_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63180 60 0 0 {name=M279_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32620 60 0 0 {name=M279_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32820 60 0 0 {name=M279_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33180 60 0 0 {name=M279_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7140 1370 0 0 {name=M280_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11100 1370 0 0 {name=M280_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63540 1370 0 0 {name=M280_tn11 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63540 1220 0 0 {name=M280_tn15 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63740 1070 0 0 {name=M280_tn14 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63740 1220 0 0 {name=M280_tn8 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 63740 1370 0 0 {name=M280_tn9 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64300 1370 0 0 {name=M280_tn18 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64300 1220 0 0 {name=M280_tn0 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64500 1220 0 0 {name=M280_tn1 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 64500 1370 0 0 {name=M280_tn12 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34460 1370 0 0 {name=M280_tn5 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34460 1220 0 0 {name=M280_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35020 1370 0 0 {name=M280_tn3 L=0.6u W=0.815u nf=1 m=1 ad=4.075e-13 as=4.075e-13 pd=2.63e-06 ps=2.63e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7140 60 0 0 {name=M280_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11100 60 0 0 {name=M280_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63540 60 0 0 {name=M280_tp9 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63540 210 0 0 {name=M280_tp15 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63940 210 0 0 {name=M280_tp7 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63740 60 0 0 {name=M280_tp6 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 63940 60 0 0 {name=M280_tp12 L=0.5u W=0.78u nf=1 m=1 ad=3.9e-13 as=3.9e-13 pd=2.56e-06 ps=2.56e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 64300 60 0 0 {name=M280_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 64300 210 0 0 {name=M280_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 64500 210 0 0 {name=M280_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 64500 60 0 0 {name=M280_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34460 60 0 0 {name=M280_tp5 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34660 60 0 0 {name=M280_tp4 L=0.5u W=1u nf=1 m=1 ad=5e-13 as=5e-13 pd=3e-06 ps=3e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35020 60 0 0 {name=M280_tp1 L=0.5u W=1.215u nf=1 m=1 ad=6.075e-13 as=6.075e-13 pd=3.43e-06 ps=3.43e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11460 1370 0 0 {name=Mtie_hi_n_tran_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11820 60 0 0 {name=Mtie_hi_p_tran_2 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
T {125} 29110 -35 0 0 0.3 0.3 {}
T {127} 1630 -35 0 0 0.3 0.3 {}
T {128} 32230 -35 0 0 0.3 0.3 {}
T {129} 33510 -35 0 0 0.3 0.3 {}
T {130} 35350 -35 0 0 0.3 0.3 {}
T {131} 27830 -35 0 0 0.3 0.3 {}
T {132} 12910 -35 0 0 0.3 0.3 {}
T {133} 13830 -35 0 0 0.3 0.3 {}
T {134} 33870 -35 0 0 0.3 0.3 {}
T {141} 35710 -35 0 0 0.3 0.3 {}
T {142} 36470 -35 0 0 0.3 0.3 {}
T {143} 37030 -35 0 0 0.3 0.3 {}
T {144} 37590 -35 0 0 0.3 0.3 {}
T {145} 38350 -35 0 0 0.3 0.3 {}
T {147} 39110 -35 0 0 0.3 0.3 {}
T {148} 39870 -35 0 0 0.3 0.3 {}
T {149} 40430 -35 0 0 0.3 0.3 {}
T {150} 40990 -35 0 0 0.3 0.3 {}
T {151} 41950 -35 0 0 0.3 0.3 {}
T {152} 42510 -35 0 0 0.3 0.3 {}
T {153} 14390 -35 0 0 0.3 0.3 {}
T {155} 43430 -35 0 0 0.3 0.3 {}
T {157} 15310 -35 0 0 0.3 0.3 {}
T {158} 110 -35 0 0 0.3 0.3 {}
T {159} 1070 -35 0 0 0.3 0.3 {}
T {160} 1990 -35 0 0 0.3 0.3 {}
T {163} 44190 -35 0 0 0.3 0.3 {}
T {164} 44750 -35 0 0 0.3 0.3 {}
T {165} 45310 -35 0 0 0.3 0.3 {}
T {166} 15870 -35 0 0 0.3 0.3 {}
T {167} 45870 -35 0 0 0.3 0.3 {}
T {168} 46430 -35 0 0 0.3 0.3 {}
T {169} 16630 -35 0 0 0.3 0.3 {}
T {170} 46990 -35 0 0 0.3 0.3 {}
T {227} 47550 -35 0 0 0.3 0.3 {}
T {228} 48510 -35 0 0 0.3 0.3 {}
T {229} 49070 -35 0 0 0.3 0.3 {}
T {230} 2950 -35 0 0 0.3 0.3 {}
T {231} 49630 -35 0 0 0.3 0.3 {}
T {232} 50190 -35 0 0 0.3 0.3 {}
T {233} 50750 -35 0 0 0.3 0.3 {}
T {234} 51670 -35 0 0 0.3 0.3 {}
T {235} 52230 -35 0 0 0.3 0.3 {}
T {236} 52790 -35 0 0 0.3 0.3 {}
T {237} 53910 -35 0 0 0.3 0.3 {}
T {238} 54470 -35 0 0 0.3 0.3 {}
T {239} 55230 -35 0 0 0.3 0.3 {}
T {240} 55790 -35 0 0 0.3 0.3 {}
T {241} 56350 -35 0 0 0.3 0.3 {}
T {251} 3510 -35 0 0 0.3 0.3 {}
T {252} 3870 -35 0 0 0.3 0.3 {}
T {253} 4230 -35 0 0 0.3 0.3 {}
T {254} 4590 -35 0 0 0.3 0.3 {}
T {255} 4950 -35 0 0 0.3 0.3 {}
T {256} 5310 -35 0 0 0.3 0.3 {}
T {257} 5670 -35 0 0 0.3 0.3 {}
T {258} 6030 -35 0 0 0.3 0.3 {}
T {278} 6390 -35 0 0 0.3 0.3 {}
T {279} 6750 -35 0 0 0.3 0.3 {}
T {280} 7110 -35 0 0 0.3 0.3 {}
T {tie_hi} 11430 -35 0 0 0.3 0.3 {}
N 29160 1400 29160 1420 {lab=0}
C {devices/gnd.sym} 29160 1420 0 0 {name=s1 lab=0}
N 29160 1370 29190 1370 {lab=0}
C {devices/gnd.sym} 29190 1370 0 0 {name=s2 lab=0}
N 29160 30 29160 10 {lab=VDD}
C {devices/vdd.sym} 29160 10 0 0 {name=s3 lab=VDD}
N 29160 60 29190 60 {lab=VDD}
C {devices/vdd.sym} 29190 60 0 0 {name=s4 lab=VDD}
N 1680 1400 1680 1420 {lab=0}
C {devices/gnd.sym} 1680 1420 0 0 {name=s5 lab=0}
N 1680 1370 1710 1370 {lab=0}
C {devices/gnd.sym} 1710 1370 0 0 {name=s6 lab=0}
N 1680 30 1680 10 {lab=VDD}
C {devices/vdd.sym} 1680 10 0 0 {name=s7 lab=VDD}
N 1680 60 1710 60 {lab=VDD}
C {devices/vdd.sym} 1710 60 0 0 {name=s8 lab=VDD}
N 32280 1400 32280 1420 {lab=0}
C {devices/gnd.sym} 32280 1420 0 0 {name=s9 lab=0}
N 32280 1370 32310 1370 {lab=0}
C {devices/gnd.sym} 32310 1370 0 0 {name=s10 lab=0}
N 32280 30 32280 10 {lab=VDD}
C {devices/vdd.sym} 32280 10 0 0 {name=s11 lab=VDD}
N 32280 60 32310 60 {lab=VDD}
C {devices/vdd.sym} 32310 60 0 0 {name=s12 lab=VDD}
N 33560 1400 33560 1420 {lab=0}
C {devices/gnd.sym} 33560 1420 0 0 {name=s13 lab=0}
N 33560 1370 33590 1370 {lab=0}
C {devices/gnd.sym} 33590 1370 0 0 {name=s14 lab=0}
N 33560 30 33560 10 {lab=VDD}
C {devices/vdd.sym} 33560 10 0 0 {name=s15 lab=VDD}
N 33560 60 33590 60 {lab=VDD}
C {devices/vdd.sym} 33590 60 0 0 {name=s16 lab=VDD}
N 35400 1400 35400 1420 {lab=0}
C {devices/gnd.sym} 35400 1420 0 0 {name=s17 lab=0}
N 35400 1370 35430 1370 {lab=0}
C {devices/gnd.sym} 35430 1370 0 0 {name=s18 lab=0}
N 35400 30 35400 10 {lab=VDD}
C {devices/vdd.sym} 35400 10 0 0 {name=s19 lab=VDD}
N 35400 60 35430 60 {lab=VDD}
C {devices/vdd.sym} 35430 60 0 0 {name=s20 lab=VDD}
N 27880 1400 27880 1420 {lab=0}
C {devices/gnd.sym} 27880 1420 0 0 {name=s21 lab=0}
N 27880 1370 27910 1370 {lab=0}
C {devices/gnd.sym} 27910 1370 0 0 {name=s22 lab=0}
N 27880 30 27880 10 {lab=VDD}
C {devices/vdd.sym} 27880 10 0 0 {name=s23 lab=VDD}
N 27880 60 27910 60 {lab=VDD}
C {devices/vdd.sym} 27910 60 0 0 {name=s24 lab=VDD}
N 12960 1220 12990 1220 {lab=0}
C {devices/gnd.sym} 12990 1220 0 0 {name=s25 lab=0}
N 12960 1400 12960 1420 {lab=0}
C {devices/gnd.sym} 12960 1420 0 0 {name=s26 lab=0}
N 12960 1370 12990 1370 {lab=0}
C {devices/gnd.sym} 12990 1370 0 0 {name=s27 lab=0}
N 13520 1400 13520 1420 {lab=0}
C {devices/gnd.sym} 13520 1420 0 0 {name=s28 lab=0}
N 13520 1370 13550 1370 {lab=0}
C {devices/gnd.sym} 13550 1370 0 0 {name=s29 lab=0}
N 12960 30 12960 10 {lab=VDD}
C {devices/vdd.sym} 12960 10 0 0 {name=s30 lab=VDD}
N 12960 60 12990 60 {lab=VDD}
C {devices/vdd.sym} 12990 60 0 0 {name=s31 lab=VDD}
N 13160 30 13160 10 {lab=VDD}
C {devices/vdd.sym} 13160 10 0 0 {name=s32 lab=VDD}
N 13160 60 13190 60 {lab=VDD}
C {devices/vdd.sym} 13190 60 0 0 {name=s33 lab=VDD}
N 13520 30 13520 10 {lab=VDD}
C {devices/vdd.sym} 13520 10 0 0 {name=s34 lab=VDD}
N 13520 60 13550 60 {lab=VDD}
C {devices/vdd.sym} 13550 60 0 0 {name=s35 lab=VDD}
N 13880 1400 13880 1420 {lab=0}
C {devices/gnd.sym} 13880 1420 0 0 {name=s36 lab=0}
N 13880 1370 13910 1370 {lab=0}
C {devices/gnd.sym} 13910 1370 0 0 {name=s37 lab=0}
N 13880 1220 13910 1220 {lab=0}
C {devices/gnd.sym} 13910 1220 0 0 {name=s38 lab=0}
N 13880 30 13880 10 {lab=VDD}
C {devices/vdd.sym} 13880 10 0 0 {name=s39 lab=VDD}
N 13880 60 13910 60 {lab=VDD}
C {devices/vdd.sym} 13910 60 0 0 {name=s40 lab=VDD}
N 14080 30 14080 10 {lab=VDD}
C {devices/vdd.sym} 14080 10 0 0 {name=s41 lab=VDD}
N 14080 60 14110 60 {lab=VDD}
C {devices/vdd.sym} 14110 60 0 0 {name=s42 lab=VDD}
N 33920 1400 33920 1420 {lab=0}
C {devices/gnd.sym} 33920 1420 0 0 {name=s43 lab=0}
N 33920 1370 33950 1370 {lab=0}
C {devices/gnd.sym} 33950 1370 0 0 {name=s44 lab=0}
N 34120 1400 34120 1420 {lab=0}
C {devices/gnd.sym} 34120 1420 0 0 {name=s45 lab=0}
N 34120 1370 34150 1370 {lab=0}
C {devices/gnd.sym} 34150 1370 0 0 {name=s46 lab=0}
N 33920 30 33920 10 {lab=VDD}
C {devices/vdd.sym} 33920 10 0 0 {name=s47 lab=VDD}
N 33920 60 33950 60 {lab=VDD}
C {devices/vdd.sym} 33950 60 0 0 {name=s48 lab=VDD}
N 33920 210 33950 210 {lab=VDD}
C {devices/vdd.sym} 33950 210 0 0 {name=s49 lab=VDD}
N 35760 1400 35760 1420 {lab=0}
C {devices/gnd.sym} 35760 1420 0 0 {name=s50 lab=0}
N 35760 1370 35790 1370 {lab=0}
C {devices/gnd.sym} 35790 1370 0 0 {name=s51 lab=0}
N 35960 1400 35960 1420 {lab=0}
C {devices/gnd.sym} 35960 1420 0 0 {name=s52 lab=0}
N 35960 1370 35990 1370 {lab=0}
C {devices/gnd.sym} 35990 1370 0 0 {name=s53 lab=0}
N 36160 1400 36160 1420 {lab=0}
C {devices/gnd.sym} 36160 1420 0 0 {name=s54 lab=0}
N 36160 1370 36190 1370 {lab=0}
C {devices/gnd.sym} 36190 1370 0 0 {name=s55 lab=0}
N 35760 30 35760 10 {lab=VDD}
C {devices/vdd.sym} 35760 10 0 0 {name=s56 lab=VDD}
N 35760 60 35790 60 {lab=VDD}
C {devices/vdd.sym} 35790 60 0 0 {name=s57 lab=VDD}
N 35760 210 35790 210 {lab=VDD}
C {devices/vdd.sym} 35790 210 0 0 {name=s58 lab=VDD}
N 35760 360 35790 360 {lab=VDD}
C {devices/vdd.sym} 35790 360 0 0 {name=s59 lab=VDD}
N 36520 1400 36520 1420 {lab=0}
C {devices/gnd.sym} 36520 1420 0 0 {name=s60 lab=0}
N 36520 1370 36550 1370 {lab=0}
C {devices/gnd.sym} 36550 1370 0 0 {name=s61 lab=0}
N 36520 1220 36550 1220 {lab=0}
C {devices/gnd.sym} 36550 1220 0 0 {name=s62 lab=0}
N 36520 30 36520 10 {lab=VDD}
C {devices/vdd.sym} 36520 10 0 0 {name=s63 lab=VDD}
N 36520 60 36550 60 {lab=VDD}
C {devices/vdd.sym} 36550 60 0 0 {name=s64 lab=VDD}
N 36720 30 36720 10 {lab=VDD}
C {devices/vdd.sym} 36720 10 0 0 {name=s65 lab=VDD}
N 36720 60 36750 60 {lab=VDD}
C {devices/vdd.sym} 36750 60 0 0 {name=s66 lab=VDD}
N 37080 1400 37080 1420 {lab=0}
C {devices/gnd.sym} 37080 1420 0 0 {name=s67 lab=0}
N 37080 1370 37110 1370 {lab=0}
C {devices/gnd.sym} 37110 1370 0 0 {name=s68 lab=0}
N 37080 1220 37110 1220 {lab=0}
C {devices/gnd.sym} 37110 1220 0 0 {name=s69 lab=0}
N 37280 1400 37280 1420 {lab=0}
C {devices/gnd.sym} 37280 1420 0 0 {name=s70 lab=0}
N 37280 1370 37310 1370 {lab=0}
C {devices/gnd.sym} 37310 1370 0 0 {name=s71 lab=0}
N 37080 210 37110 210 {lab=VDD}
C {devices/vdd.sym} 37110 210 0 0 {name=s72 lab=VDD}
N 37280 210 37310 210 {lab=VDD}
C {devices/vdd.sym} 37310 210 0 0 {name=s73 lab=VDD}
N 37080 30 37080 10 {lab=VDD}
C {devices/vdd.sym} 37080 10 0 0 {name=s74 lab=VDD}
N 37080 60 37110 60 {lab=VDD}
C {devices/vdd.sym} 37110 60 0 0 {name=s75 lab=VDD}
N 37640 1400 37640 1420 {lab=0}
C {devices/gnd.sym} 37640 1420 0 0 {name=s76 lab=0}
N 37640 1370 37670 1370 {lab=0}
C {devices/gnd.sym} 37670 1370 0 0 {name=s77 lab=0}
N 37640 1220 37670 1220 {lab=0}
C {devices/gnd.sym} 37670 1220 0 0 {name=s78 lab=0}
N 37640 1070 37670 1070 {lab=0}
C {devices/gnd.sym} 37670 1070 0 0 {name=s79 lab=0}
N 37640 30 37640 10 {lab=VDD}
C {devices/vdd.sym} 37640 10 0 0 {name=s80 lab=VDD}
N 37640 60 37670 60 {lab=VDD}
C {devices/vdd.sym} 37670 60 0 0 {name=s81 lab=VDD}
N 37840 30 37840 10 {lab=VDD}
C {devices/vdd.sym} 37840 10 0 0 {name=s82 lab=VDD}
N 37840 60 37870 60 {lab=VDD}
C {devices/vdd.sym} 37870 60 0 0 {name=s83 lab=VDD}
N 38040 30 38040 10 {lab=VDD}
C {devices/vdd.sym} 38040 10 0 0 {name=s84 lab=VDD}
N 38040 60 38070 60 {lab=VDD}
C {devices/vdd.sym} 38070 60 0 0 {name=s85 lab=VDD}
N 38400 1400 38400 1420 {lab=0}
C {devices/gnd.sym} 38400 1420 0 0 {name=s86 lab=0}
N 38400 1370 38430 1370 {lab=0}
C {devices/gnd.sym} 38430 1370 0 0 {name=s87 lab=0}
N 38600 1400 38600 1420 {lab=0}
C {devices/gnd.sym} 38600 1420 0 0 {name=s88 lab=0}
N 38600 1370 38630 1370 {lab=0}
C {devices/gnd.sym} 38630 1370 0 0 {name=s89 lab=0}
N 38800 1400 38800 1420 {lab=0}
C {devices/gnd.sym} 38800 1420 0 0 {name=s90 lab=0}
N 38800 1370 38830 1370 {lab=0}
C {devices/gnd.sym} 38830 1370 0 0 {name=s91 lab=0}
N 38400 30 38400 10 {lab=VDD}
C {devices/vdd.sym} 38400 10 0 0 {name=s92 lab=VDD}
N 38400 60 38430 60 {lab=VDD}
C {devices/vdd.sym} 38430 60 0 0 {name=s93 lab=VDD}
N 38400 210 38430 210 {lab=VDD}
C {devices/vdd.sym} 38430 210 0 0 {name=s94 lab=VDD}
N 38400 360 38430 360 {lab=VDD}
C {devices/vdd.sym} 38430 360 0 0 {name=s95 lab=VDD}
N 39160 1400 39160 1420 {lab=0}
C {devices/gnd.sym} 39160 1420 0 0 {name=s96 lab=0}
N 39160 1370 39190 1370 {lab=0}
C {devices/gnd.sym} 39190 1370 0 0 {name=s97 lab=0}
N 39360 1400 39360 1420 {lab=0}
C {devices/gnd.sym} 39360 1420 0 0 {name=s98 lab=0}
N 39360 1370 39390 1370 {lab=0}
C {devices/gnd.sym} 39390 1370 0 0 {name=s99 lab=0}
N 39560 1400 39560 1420 {lab=0}
C {devices/gnd.sym} 39560 1420 0 0 {name=s100 lab=0}
N 39560 1370 39590 1370 {lab=0}
C {devices/gnd.sym} 39590 1370 0 0 {name=s101 lab=0}
N 39160 30 39160 10 {lab=VDD}
C {devices/vdd.sym} 39160 10 0 0 {name=s102 lab=VDD}
N 39160 60 39190 60 {lab=VDD}
C {devices/vdd.sym} 39190 60 0 0 {name=s103 lab=VDD}
N 39160 210 39190 210 {lab=VDD}
C {devices/vdd.sym} 39190 210 0 0 {name=s104 lab=VDD}
N 39160 360 39190 360 {lab=VDD}
C {devices/vdd.sym} 39190 360 0 0 {name=s105 lab=VDD}
N 39920 1400 39920 1420 {lab=0}
C {devices/gnd.sym} 39920 1420 0 0 {name=s106 lab=0}
N 39920 1370 39950 1370 {lab=0}
C {devices/gnd.sym} 39950 1370 0 0 {name=s107 lab=0}
N 39920 1220 39950 1220 {lab=0}
C {devices/gnd.sym} 39950 1220 0 0 {name=s108 lab=0}
N 40120 1400 40120 1420 {lab=0}
C {devices/gnd.sym} 40120 1420 0 0 {name=s109 lab=0}
N 40120 1370 40150 1370 {lab=0}
C {devices/gnd.sym} 40150 1370 0 0 {name=s110 lab=0}
N 39920 210 39950 210 {lab=VDD}
C {devices/vdd.sym} 39950 210 0 0 {name=s111 lab=VDD}
N 40120 210 40150 210 {lab=VDD}
C {devices/vdd.sym} 40150 210 0 0 {name=s112 lab=VDD}
N 39920 30 39920 10 {lab=VDD}
C {devices/vdd.sym} 39920 10 0 0 {name=s113 lab=VDD}
N 39920 60 39950 60 {lab=VDD}
C {devices/vdd.sym} 39950 60 0 0 {name=s114 lab=VDD}
N 40480 1400 40480 1420 {lab=0}
C {devices/gnd.sym} 40480 1420 0 0 {name=s115 lab=0}
N 40480 1370 40510 1370 {lab=0}
C {devices/gnd.sym} 40510 1370 0 0 {name=s116 lab=0}
N 40680 1400 40680 1420 {lab=0}
C {devices/gnd.sym} 40680 1420 0 0 {name=s117 lab=0}
N 40680 1370 40710 1370 {lab=0}
C {devices/gnd.sym} 40710 1370 0 0 {name=s118 lab=0}
N 40680 1220 40710 1220 {lab=0}
C {devices/gnd.sym} 40710 1220 0 0 {name=s119 lab=0}
N 40480 1220 40510 1220 {lab=0}
C {devices/gnd.sym} 40510 1220 0 0 {name=s120 lab=0}
N 40480 30 40480 10 {lab=VDD}
C {devices/vdd.sym} 40480 10 0 0 {name=s121 lab=VDD}
N 40480 60 40510 60 {lab=VDD}
C {devices/vdd.sym} 40510 60 0 0 {name=s122 lab=VDD}
N 40480 210 40510 210 {lab=VDD}
C {devices/vdd.sym} 40510 210 0 0 {name=s123 lab=VDD}
N 40680 210 40710 210 {lab=VDD}
C {devices/vdd.sym} 40710 210 0 0 {name=s124 lab=VDD}
N 40680 30 40680 10 {lab=VDD}
C {devices/vdd.sym} 40680 10 0 0 {name=s125 lab=VDD}
N 40680 60 40710 60 {lab=VDD}
C {devices/vdd.sym} 40710 60 0 0 {name=s126 lab=VDD}
N 41040 1400 41040 1420 {lab=0}
C {devices/gnd.sym} 41040 1420 0 0 {name=s127 lab=0}
N 41040 1370 41070 1370 {lab=0}
C {devices/gnd.sym} 41070 1370 0 0 {name=s128 lab=0}
N 41240 1400 41240 1420 {lab=0}
C {devices/gnd.sym} 41240 1420 0 0 {name=s129 lab=0}
N 41240 1370 41270 1370 {lab=0}
C {devices/gnd.sym} 41270 1370 0 0 {name=s130 lab=0}
N 41440 1400 41440 1420 {lab=0}
C {devices/gnd.sym} 41440 1420 0 0 {name=s131 lab=0}
N 41440 1370 41470 1370 {lab=0}
C {devices/gnd.sym} 41470 1370 0 0 {name=s132 lab=0}
N 41640 1400 41640 1420 {lab=0}
C {devices/gnd.sym} 41640 1420 0 0 {name=s133 lab=0}
N 41640 1370 41670 1370 {lab=0}
C {devices/gnd.sym} 41670 1370 0 0 {name=s134 lab=0}
N 41040 30 41040 10 {lab=VDD}
C {devices/vdd.sym} 41040 10 0 0 {name=s135 lab=VDD}
N 41040 60 41070 60 {lab=VDD}
C {devices/vdd.sym} 41070 60 0 0 {name=s136 lab=VDD}
N 41040 210 41070 210 {lab=VDD}
C {devices/vdd.sym} 41070 210 0 0 {name=s137 lab=VDD}
N 41040 360 41070 360 {lab=VDD}
C {devices/vdd.sym} 41070 360 0 0 {name=s138 lab=VDD}
N 41040 510 41070 510 {lab=VDD}
C {devices/vdd.sym} 41070 510 0 0 {name=s139 lab=VDD}
N 42000 1400 42000 1420 {lab=0}
C {devices/gnd.sym} 42000 1420 0 0 {name=s140 lab=0}
N 42000 1370 42030 1370 {lab=0}
C {devices/gnd.sym} 42030 1370 0 0 {name=s141 lab=0}
N 42000 1220 42030 1220 {lab=0}
C {devices/gnd.sym} 42030 1220 0 0 {name=s142 lab=0}
N 42000 30 42000 10 {lab=VDD}
C {devices/vdd.sym} 42000 10 0 0 {name=s143 lab=VDD}
N 42000 60 42030 60 {lab=VDD}
C {devices/vdd.sym} 42030 60 0 0 {name=s144 lab=VDD}
N 42200 30 42200 10 {lab=VDD}
C {devices/vdd.sym} 42200 10 0 0 {name=s145 lab=VDD}
N 42200 60 42230 60 {lab=VDD}
C {devices/vdd.sym} 42230 60 0 0 {name=s146 lab=VDD}
N 42560 1400 42560 1420 {lab=0}
C {devices/gnd.sym} 42560 1420 0 0 {name=s147 lab=0}
N 42560 1370 42590 1370 {lab=0}
C {devices/gnd.sym} 42590 1370 0 0 {name=s148 lab=0}
N 42760 1400 42760 1420 {lab=0}
C {devices/gnd.sym} 42760 1420 0 0 {name=s149 lab=0}
N 42760 1370 42790 1370 {lab=0}
C {devices/gnd.sym} 42790 1370 0 0 {name=s150 lab=0}
N 43120 1400 43120 1420 {lab=0}
C {devices/gnd.sym} 43120 1420 0 0 {name=s151 lab=0}
N 43120 1370 43150 1370 {lab=0}
C {devices/gnd.sym} 43150 1370 0 0 {name=s152 lab=0}
N 42560 210 42590 210 {lab=VDD}
C {devices/vdd.sym} 42590 210 0 0 {name=s153 lab=VDD}
N 42560 30 42560 10 {lab=VDD}
C {devices/vdd.sym} 42560 10 0 0 {name=s154 lab=VDD}
N 42560 60 42590 60 {lab=VDD}
C {devices/vdd.sym} 42590 60 0 0 {name=s155 lab=VDD}
N 43120 30 43120 10 {lab=VDD}
C {devices/vdd.sym} 43120 10 0 0 {name=s156 lab=VDD}
N 43120 60 43150 60 {lab=VDD}
C {devices/vdd.sym} 43150 60 0 0 {name=s157 lab=VDD}
N 14440 1220 14470 1220 {lab=0}
C {devices/gnd.sym} 14470 1220 0 0 {name=s158 lab=0}
N 14440 1400 14440 1420 {lab=0}
C {devices/gnd.sym} 14440 1420 0 0 {name=s159 lab=0}
N 14440 1370 14470 1370 {lab=0}
C {devices/gnd.sym} 14470 1370 0 0 {name=s160 lab=0}
N 15000 1400 15000 1420 {lab=0}
C {devices/gnd.sym} 15000 1420 0 0 {name=s161 lab=0}
N 15000 1370 15030 1370 {lab=0}
C {devices/gnd.sym} 15030 1370 0 0 {name=s162 lab=0}
N 14440 30 14440 10 {lab=VDD}
C {devices/vdd.sym} 14440 10 0 0 {name=s163 lab=VDD}
N 14440 60 14470 60 {lab=VDD}
C {devices/vdd.sym} 14470 60 0 0 {name=s164 lab=VDD}
N 14640 30 14640 10 {lab=VDD}
C {devices/vdd.sym} 14640 10 0 0 {name=s165 lab=VDD}
N 14640 60 14670 60 {lab=VDD}
C {devices/vdd.sym} 14670 60 0 0 {name=s166 lab=VDD}
N 15000 30 15000 10 {lab=VDD}
C {devices/vdd.sym} 15000 10 0 0 {name=s167 lab=VDD}
N 15000 60 15030 60 {lab=VDD}
C {devices/vdd.sym} 15030 60 0 0 {name=s168 lab=VDD}
N 43480 1400 43480 1420 {lab=0}
C {devices/gnd.sym} 43480 1420 0 0 {name=s169 lab=0}
N 43480 1370 43510 1370 {lab=0}
C {devices/gnd.sym} 43510 1370 0 0 {name=s170 lab=0}
N 43680 1400 43680 1420 {lab=0}
C {devices/gnd.sym} 43680 1420 0 0 {name=s171 lab=0}
N 43680 1370 43710 1370 {lab=0}
C {devices/gnd.sym} 43710 1370 0 0 {name=s172 lab=0}
N 43880 1400 43880 1420 {lab=0}
C {devices/gnd.sym} 43880 1420 0 0 {name=s173 lab=0}
N 43880 1370 43910 1370 {lab=0}
C {devices/gnd.sym} 43910 1370 0 0 {name=s174 lab=0}
N 43480 30 43480 10 {lab=VDD}
C {devices/vdd.sym} 43480 10 0 0 {name=s175 lab=VDD}
N 43480 60 43510 60 {lab=VDD}
C {devices/vdd.sym} 43510 60 0 0 {name=s176 lab=VDD}
N 43480 210 43510 210 {lab=VDD}
C {devices/vdd.sym} 43510 210 0 0 {name=s177 lab=VDD}
N 43480 360 43510 360 {lab=VDD}
C {devices/vdd.sym} 43510 360 0 0 {name=s178 lab=VDD}
N 15360 1400 15360 1420 {lab=0}
C {devices/gnd.sym} 15360 1420 0 0 {name=s179 lab=0}
N 15360 1370 15390 1370 {lab=0}
C {devices/gnd.sym} 15390 1370 0 0 {name=s180 lab=0}
N 15560 1400 15560 1420 {lab=0}
C {devices/gnd.sym} 15560 1420 0 0 {name=s181 lab=0}
N 15560 1370 15590 1370 {lab=0}
C {devices/gnd.sym} 15590 1370 0 0 {name=s182 lab=0}
N 15360 30 15360 10 {lab=VDD}
C {devices/vdd.sym} 15360 10 0 0 {name=s183 lab=VDD}
N 15360 60 15390 60 {lab=VDD}
C {devices/vdd.sym} 15390 60 0 0 {name=s184 lab=VDD}
N 15360 210 15390 210 {lab=VDD}
C {devices/vdd.sym} 15390 210 0 0 {name=s185 lab=VDD}
N 160 1400 160 1420 {lab=0}
C {devices/gnd.sym} 160 1420 0 0 {name=s186 lab=0}
N 160 1370 190 1370 {lab=0}
C {devices/gnd.sym} 190 1370 0 0 {name=s187 lab=0}
N 160 1220 190 1220 {lab=0}
C {devices/gnd.sym} 190 1220 0 0 {name=s188 lab=0}
N 160 1070 190 1070 {lab=0}
C {devices/gnd.sym} 190 1070 0 0 {name=s189 lab=0}
N 160 920 190 920 {lab=0}
C {devices/gnd.sym} 190 920 0 0 {name=s190 lab=0}
N 160 30 160 10 {lab=VDD}
C {devices/vdd.sym} 160 10 0 0 {name=s191 lab=VDD}
N 160 60 190 60 {lab=VDD}
C {devices/vdd.sym} 190 60 0 0 {name=s192 lab=VDD}
N 360 30 360 10 {lab=VDD}
C {devices/vdd.sym} 360 10 0 0 {name=s193 lab=VDD}
N 360 60 390 60 {lab=VDD}
C {devices/vdd.sym} 390 60 0 0 {name=s194 lab=VDD}
N 560 30 560 10 {lab=VDD}
C {devices/vdd.sym} 560 10 0 0 {name=s195 lab=VDD}
N 560 60 590 60 {lab=VDD}
C {devices/vdd.sym} 590 60 0 0 {name=s196 lab=VDD}
N 760 30 760 10 {lab=VDD}
C {devices/vdd.sym} 760 10 0 0 {name=s197 lab=VDD}
N 760 60 790 60 {lab=VDD}
C {devices/vdd.sym} 790 60 0 0 {name=s198 lab=VDD}
N 1120 1400 1120 1420 {lab=0}
C {devices/gnd.sym} 1120 1420 0 0 {name=s199 lab=0}
N 1120 1370 1150 1370 {lab=0}
C {devices/gnd.sym} 1150 1370 0 0 {name=s200 lab=0}
N 1120 1220 1150 1220 {lab=0}
C {devices/gnd.sym} 1150 1220 0 0 {name=s201 lab=0}
N 1120 30 1120 10 {lab=VDD}
C {devices/vdd.sym} 1120 10 0 0 {name=s202 lab=VDD}
N 1120 60 1150 60 {lab=VDD}
C {devices/vdd.sym} 1150 60 0 0 {name=s203 lab=VDD}
N 1320 30 1320 10 {lab=VDD}
C {devices/vdd.sym} 1320 10 0 0 {name=s204 lab=VDD}
N 1320 60 1350 60 {lab=VDD}
C {devices/vdd.sym} 1350 60 0 0 {name=s205 lab=VDD}
N 2040 1400 2040 1420 {lab=0}
C {devices/gnd.sym} 2040 1420 0 0 {name=s206 lab=0}
N 2040 1370 2070 1370 {lab=0}
C {devices/gnd.sym} 2070 1370 0 0 {name=s207 lab=0}
N 2240 1400 2240 1420 {lab=0}
C {devices/gnd.sym} 2240 1420 0 0 {name=s208 lab=0}
N 2240 1370 2270 1370 {lab=0}
C {devices/gnd.sym} 2270 1370 0 0 {name=s209 lab=0}
N 2440 1400 2440 1420 {lab=0}
C {devices/gnd.sym} 2440 1420 0 0 {name=s210 lab=0}
N 2440 1370 2470 1370 {lab=0}
C {devices/gnd.sym} 2470 1370 0 0 {name=s211 lab=0}
N 2640 1400 2640 1420 {lab=0}
C {devices/gnd.sym} 2640 1420 0 0 {name=s212 lab=0}
N 2640 1370 2670 1370 {lab=0}
C {devices/gnd.sym} 2670 1370 0 0 {name=s213 lab=0}
N 2040 30 2040 10 {lab=VDD}
C {devices/vdd.sym} 2040 10 0 0 {name=s214 lab=VDD}
N 2040 60 2070 60 {lab=VDD}
C {devices/vdd.sym} 2070 60 0 0 {name=s215 lab=VDD}
N 2040 210 2070 210 {lab=VDD}
C {devices/vdd.sym} 2070 210 0 0 {name=s216 lab=VDD}
N 2040 360 2070 360 {lab=VDD}
C {devices/vdd.sym} 2070 360 0 0 {name=s217 lab=VDD}
N 2040 510 2070 510 {lab=VDD}
C {devices/vdd.sym} 2070 510 0 0 {name=s218 lab=VDD}
N 44240 1400 44240 1420 {lab=0}
C {devices/gnd.sym} 44240 1420 0 0 {name=s219 lab=0}
N 44240 1370 44270 1370 {lab=0}
C {devices/gnd.sym} 44270 1370 0 0 {name=s220 lab=0}
N 44440 1400 44440 1420 {lab=0}
C {devices/gnd.sym} 44440 1420 0 0 {name=s221 lab=0}
N 44440 1370 44470 1370 {lab=0}
C {devices/gnd.sym} 44470 1370 0 0 {name=s222 lab=0}
N 44240 30 44240 10 {lab=VDD}
C {devices/vdd.sym} 44240 10 0 0 {name=s223 lab=VDD}
N 44240 60 44270 60 {lab=VDD}
C {devices/vdd.sym} 44270 60 0 0 {name=s224 lab=VDD}
N 44240 210 44270 210 {lab=VDD}
C {devices/vdd.sym} 44270 210 0 0 {name=s225 lab=VDD}
N 44800 1400 44800 1420 {lab=0}
C {devices/gnd.sym} 44800 1420 0 0 {name=s226 lab=0}
N 44800 1370 44830 1370 {lab=0}
C {devices/gnd.sym} 44830 1370 0 0 {name=s227 lab=0}
N 44800 1220 44830 1220 {lab=0}
C {devices/gnd.sym} 44830 1220 0 0 {name=s228 lab=0}
N 44800 30 44800 10 {lab=VDD}
C {devices/vdd.sym} 44800 10 0 0 {name=s229 lab=VDD}
N 44800 60 44830 60 {lab=VDD}
C {devices/vdd.sym} 44830 60 0 0 {name=s230 lab=VDD}
N 45000 30 45000 10 {lab=VDD}
C {devices/vdd.sym} 45000 10 0 0 {name=s231 lab=VDD}
N 45000 60 45030 60 {lab=VDD}
C {devices/vdd.sym} 45030 60 0 0 {name=s232 lab=VDD}
N 45360 1400 45360 1420 {lab=0}
C {devices/gnd.sym} 45360 1420 0 0 {name=s233 lab=0}
N 45360 1370 45390 1370 {lab=0}
C {devices/gnd.sym} 45390 1370 0 0 {name=s234 lab=0}
N 45360 1220 45390 1220 {lab=0}
C {devices/gnd.sym} 45390 1220 0 0 {name=s235 lab=0}
N 45360 30 45360 10 {lab=VDD}
C {devices/vdd.sym} 45360 10 0 0 {name=s236 lab=VDD}
N 45360 60 45390 60 {lab=VDD}
C {devices/vdd.sym} 45390 60 0 0 {name=s237 lab=VDD}
N 45560 30 45560 10 {lab=VDD}
C {devices/vdd.sym} 45560 10 0 0 {name=s238 lab=VDD}
N 45560 60 45590 60 {lab=VDD}
C {devices/vdd.sym} 45590 60 0 0 {name=s239 lab=VDD}
N 15920 1400 15920 1420 {lab=0}
C {devices/gnd.sym} 15920 1420 0 0 {name=s240 lab=0}
N 15920 1370 15950 1370 {lab=0}
C {devices/gnd.sym} 15950 1370 0 0 {name=s241 lab=0}
N 15920 1220 15950 1220 {lab=0}
C {devices/gnd.sym} 15950 1220 0 0 {name=s242 lab=0}
N 15920 1070 15950 1070 {lab=0}
C {devices/gnd.sym} 15950 1070 0 0 {name=s243 lab=0}
N 15920 30 15920 10 {lab=VDD}
C {devices/vdd.sym} 15920 10 0 0 {name=s244 lab=VDD}
N 15920 60 15950 60 {lab=VDD}
C {devices/vdd.sym} 15950 60 0 0 {name=s245 lab=VDD}
N 16120 30 16120 10 {lab=VDD}
C {devices/vdd.sym} 16120 10 0 0 {name=s246 lab=VDD}
N 16120 60 16150 60 {lab=VDD}
C {devices/vdd.sym} 16150 60 0 0 {name=s247 lab=VDD}
N 16320 30 16320 10 {lab=VDD}
C {devices/vdd.sym} 16320 10 0 0 {name=s248 lab=VDD}
N 16320 60 16350 60 {lab=VDD}
C {devices/vdd.sym} 16350 60 0 0 {name=s249 lab=VDD}
N 45920 1400 45920 1420 {lab=0}
C {devices/gnd.sym} 45920 1420 0 0 {name=s250 lab=0}
N 45920 1370 45950 1370 {lab=0}
C {devices/gnd.sym} 45950 1370 0 0 {name=s251 lab=0}
N 45920 1220 45950 1220 {lab=0}
C {devices/gnd.sym} 45950 1220 0 0 {name=s252 lab=0}
N 45920 30 45920 10 {lab=VDD}
C {devices/vdd.sym} 45920 10 0 0 {name=s253 lab=VDD}
N 45920 60 45950 60 {lab=VDD}
C {devices/vdd.sym} 45950 60 0 0 {name=s254 lab=VDD}
N 46120 30 46120 10 {lab=VDD}
C {devices/vdd.sym} 46120 10 0 0 {name=s255 lab=VDD}
N 46120 60 46150 60 {lab=VDD}
C {devices/vdd.sym} 46150 60 0 0 {name=s256 lab=VDD}
N 46480 1400 46480 1420 {lab=0}
C {devices/gnd.sym} 46480 1420 0 0 {name=s257 lab=0}
N 46480 1370 46510 1370 {lab=0}
C {devices/gnd.sym} 46510 1370 0 0 {name=s258 lab=0}
N 46480 1220 46510 1220 {lab=0}
C {devices/gnd.sym} 46510 1220 0 0 {name=s259 lab=0}
N 46480 30 46480 10 {lab=VDD}
C {devices/vdd.sym} 46480 10 0 0 {name=s260 lab=VDD}
N 46480 60 46510 60 {lab=VDD}
C {devices/vdd.sym} 46510 60 0 0 {name=s261 lab=VDD}
N 46680 30 46680 10 {lab=VDD}
C {devices/vdd.sym} 46680 10 0 0 {name=s262 lab=VDD}
N 46680 60 46710 60 {lab=VDD}
C {devices/vdd.sym} 46710 60 0 0 {name=s263 lab=VDD}
N 16680 1400 16680 1420 {lab=0}
C {devices/gnd.sym} 16680 1420 0 0 {name=s264 lab=0}
N 16680 1370 16710 1370 {lab=0}
C {devices/gnd.sym} 16710 1370 0 0 {name=s265 lab=0}
N 16680 1220 16710 1220 {lab=0}
C {devices/gnd.sym} 16710 1220 0 0 {name=s266 lab=0}
N 16680 1070 16710 1070 {lab=0}
C {devices/gnd.sym} 16710 1070 0 0 {name=s267 lab=0}
N 16680 30 16680 10 {lab=VDD}
C {devices/vdd.sym} 16680 10 0 0 {name=s268 lab=VDD}
N 16680 60 16710 60 {lab=VDD}
C {devices/vdd.sym} 16710 60 0 0 {name=s269 lab=VDD}
N 16880 30 16880 10 {lab=VDD}
C {devices/vdd.sym} 16880 10 0 0 {name=s270 lab=VDD}
N 16880 60 16910 60 {lab=VDD}
C {devices/vdd.sym} 16910 60 0 0 {name=s271 lab=VDD}
N 17080 30 17080 10 {lab=VDD}
C {devices/vdd.sym} 17080 10 0 0 {name=s272 lab=VDD}
N 17080 60 17110 60 {lab=VDD}
C {devices/vdd.sym} 17110 60 0 0 {name=s273 lab=VDD}
N 47040 1400 47040 1420 {lab=0}
C {devices/gnd.sym} 47040 1420 0 0 {name=s274 lab=0}
N 47040 1370 47070 1370 {lab=0}
C {devices/gnd.sym} 47070 1370 0 0 {name=s275 lab=0}
N 47040 1220 47070 1220 {lab=0}
C {devices/gnd.sym} 47070 1220 0 0 {name=s276 lab=0}
N 47040 30 47040 10 {lab=VDD}
C {devices/vdd.sym} 47040 10 0 0 {name=s277 lab=VDD}
N 47040 60 47070 60 {lab=VDD}
C {devices/vdd.sym} 47070 60 0 0 {name=s278 lab=VDD}
N 47240 30 47240 10 {lab=VDD}
C {devices/vdd.sym} 47240 10 0 0 {name=s279 lab=VDD}
N 47240 60 47270 60 {lab=VDD}
C {devices/vdd.sym} 47270 60 0 0 {name=s280 lab=VDD}
N 47600 1400 47600 1420 {lab=0}
C {devices/gnd.sym} 47600 1420 0 0 {name=s281 lab=0}
N 47600 1370 47630 1370 {lab=0}
C {devices/gnd.sym} 47630 1370 0 0 {name=s282 lab=0}
N 47600 1220 47630 1220 {lab=0}
C {devices/gnd.sym} 47630 1220 0 0 {name=s283 lab=0}
N 47600 1070 47630 1070 {lab=0}
C {devices/gnd.sym} 47630 1070 0 0 {name=s284 lab=0}
N 47600 920 47630 920 {lab=0}
C {devices/gnd.sym} 47630 920 0 0 {name=s285 lab=0}
N 47600 30 47600 10 {lab=VDD}
C {devices/vdd.sym} 47600 10 0 0 {name=s286 lab=VDD}
N 47600 60 47630 60 {lab=VDD}
C {devices/vdd.sym} 47630 60 0 0 {name=s287 lab=VDD}
N 47800 30 47800 10 {lab=VDD}
C {devices/vdd.sym} 47800 10 0 0 {name=s288 lab=VDD}
N 47800 60 47830 60 {lab=VDD}
C {devices/vdd.sym} 47830 60 0 0 {name=s289 lab=VDD}
N 48000 30 48000 10 {lab=VDD}
C {devices/vdd.sym} 48000 10 0 0 {name=s290 lab=VDD}
N 48000 60 48030 60 {lab=VDD}
C {devices/vdd.sym} 48030 60 0 0 {name=s291 lab=VDD}
N 48200 30 48200 10 {lab=VDD}
C {devices/vdd.sym} 48200 10 0 0 {name=s292 lab=VDD}
N 48200 60 48230 60 {lab=VDD}
C {devices/vdd.sym} 48230 60 0 0 {name=s293 lab=VDD}
N 48560 1400 48560 1420 {lab=0}
C {devices/gnd.sym} 48560 1420 0 0 {name=s294 lab=0}
N 48560 1370 48590 1370 {lab=0}
C {devices/gnd.sym} 48590 1370 0 0 {name=s295 lab=0}
N 48760 1400 48760 1420 {lab=0}
C {devices/gnd.sym} 48760 1420 0 0 {name=s296 lab=0}
N 48760 1370 48790 1370 {lab=0}
C {devices/gnd.sym} 48790 1370 0 0 {name=s297 lab=0}
N 48560 30 48560 10 {lab=VDD}
C {devices/vdd.sym} 48560 10 0 0 {name=s298 lab=VDD}
N 48560 60 48590 60 {lab=VDD}
C {devices/vdd.sym} 48590 60 0 0 {name=s299 lab=VDD}
N 48560 210 48590 210 {lab=VDD}
C {devices/vdd.sym} 48590 210 0 0 {name=s300 lab=VDD}
N 49120 1400 49120 1420 {lab=0}
C {devices/gnd.sym} 49120 1420 0 0 {name=s301 lab=0}
N 49120 1370 49150 1370 {lab=0}
C {devices/gnd.sym} 49150 1370 0 0 {name=s302 lab=0}
N 49120 1220 49150 1220 {lab=0}
C {devices/gnd.sym} 49150 1220 0 0 {name=s303 lab=0}
N 49120 30 49120 10 {lab=VDD}
C {devices/vdd.sym} 49120 10 0 0 {name=s304 lab=VDD}
N 49120 60 49150 60 {lab=VDD}
C {devices/vdd.sym} 49150 60 0 0 {name=s305 lab=VDD}
N 49320 30 49320 10 {lab=VDD}
C {devices/vdd.sym} 49320 10 0 0 {name=s306 lab=VDD}
N 49320 60 49350 60 {lab=VDD}
C {devices/vdd.sym} 49350 60 0 0 {name=s307 lab=VDD}
N 3000 1400 3000 1420 {lab=0}
C {devices/gnd.sym} 3000 1420 0 0 {name=s308 lab=0}
N 3000 1370 3030 1370 {lab=0}
C {devices/gnd.sym} 3030 1370 0 0 {name=s309 lab=0}
N 3200 1400 3200 1420 {lab=0}
C {devices/gnd.sym} 3200 1420 0 0 {name=s310 lab=0}
N 3200 1370 3230 1370 {lab=0}
C {devices/gnd.sym} 3230 1370 0 0 {name=s311 lab=0}
N 3000 30 3000 10 {lab=VDD}
C {devices/vdd.sym} 3000 10 0 0 {name=s312 lab=VDD}
N 3000 60 3030 60 {lab=VDD}
C {devices/vdd.sym} 3030 60 0 0 {name=s313 lab=VDD}
N 3000 210 3030 210 {lab=VDD}
C {devices/vdd.sym} 3030 210 0 0 {name=s314 lab=VDD}
N 49680 1400 49680 1420 {lab=0}
C {devices/gnd.sym} 49680 1420 0 0 {name=s315 lab=0}
N 49680 1370 49710 1370 {lab=0}
C {devices/gnd.sym} 49710 1370 0 0 {name=s316 lab=0}
N 49680 1220 49710 1220 {lab=0}
C {devices/gnd.sym} 49710 1220 0 0 {name=s317 lab=0}
N 49680 30 49680 10 {lab=VDD}
C {devices/vdd.sym} 49680 10 0 0 {name=s318 lab=VDD}
N 49680 60 49710 60 {lab=VDD}
C {devices/vdd.sym} 49710 60 0 0 {name=s319 lab=VDD}
N 49880 30 49880 10 {lab=VDD}
C {devices/vdd.sym} 49880 10 0 0 {name=s320 lab=VDD}
N 49880 60 49910 60 {lab=VDD}
C {devices/vdd.sym} 49910 60 0 0 {name=s321 lab=VDD}
N 50240 1220 50270 1220 {lab=0}
C {devices/gnd.sym} 50270 1220 0 0 {name=s322 lab=0}
N 50440 1220 50470 1220 {lab=0}
C {devices/gnd.sym} 50470 1220 0 0 {name=s323 lab=0}
N 50240 1400 50240 1420 {lab=0}
C {devices/gnd.sym} 50240 1420 0 0 {name=s324 lab=0}
N 50240 1370 50270 1370 {lab=0}
C {devices/gnd.sym} 50270 1370 0 0 {name=s325 lab=0}
N 50240 30 50240 10 {lab=VDD}
C {devices/vdd.sym} 50240 10 0 0 {name=s326 lab=VDD}
N 50240 60 50270 60 {lab=VDD}
C {devices/vdd.sym} 50270 60 0 0 {name=s327 lab=VDD}
N 50240 210 50270 210 {lab=VDD}
C {devices/vdd.sym} 50270 210 0 0 {name=s328 lab=VDD}
N 50440 30 50440 10 {lab=VDD}
C {devices/vdd.sym} 50440 10 0 0 {name=s329 lab=VDD}
N 50440 60 50470 60 {lab=VDD}
C {devices/vdd.sym} 50470 60 0 0 {name=s330 lab=VDD}
N 50800 1220 50830 1220 {lab=0}
C {devices/gnd.sym} 50830 1220 0 0 {name=s331 lab=0}
N 50800 1400 50800 1420 {lab=0}
C {devices/gnd.sym} 50800 1420 0 0 {name=s332 lab=0}
N 50800 1370 50830 1370 {lab=0}
C {devices/gnd.sym} 50830 1370 0 0 {name=s333 lab=0}
N 51360 1400 51360 1420 {lab=0}
C {devices/gnd.sym} 51360 1420 0 0 {name=s334 lab=0}
N 51360 1370 51390 1370 {lab=0}
C {devices/gnd.sym} 51390 1370 0 0 {name=s335 lab=0}
N 50800 30 50800 10 {lab=VDD}
C {devices/vdd.sym} 50800 10 0 0 {name=s336 lab=VDD}
N 50800 60 50830 60 {lab=VDD}
C {devices/vdd.sym} 50830 60 0 0 {name=s337 lab=VDD}
N 51000 30 51000 10 {lab=VDD}
C {devices/vdd.sym} 51000 10 0 0 {name=s338 lab=VDD}
N 51000 60 51030 60 {lab=VDD}
C {devices/vdd.sym} 51030 60 0 0 {name=s339 lab=VDD}
N 51360 30 51360 10 {lab=VDD}
C {devices/vdd.sym} 51360 10 0 0 {name=s340 lab=VDD}
N 51360 60 51390 60 {lab=VDD}
C {devices/vdd.sym} 51390 60 0 0 {name=s341 lab=VDD}
N 51720 1220 51750 1220 {lab=0}
C {devices/gnd.sym} 51750 1220 0 0 {name=s342 lab=0}
N 51920 1220 51950 1220 {lab=0}
C {devices/gnd.sym} 51950 1220 0 0 {name=s343 lab=0}
N 51720 1400 51720 1420 {lab=0}
C {devices/gnd.sym} 51720 1420 0 0 {name=s344 lab=0}
N 51720 1370 51750 1370 {lab=0}
C {devices/gnd.sym} 51750 1370 0 0 {name=s345 lab=0}
N 51720 30 51720 10 {lab=VDD}
C {devices/vdd.sym} 51720 10 0 0 {name=s346 lab=VDD}
N 51720 60 51750 60 {lab=VDD}
C {devices/vdd.sym} 51750 60 0 0 {name=s347 lab=VDD}
N 51720 210 51750 210 {lab=VDD}
C {devices/vdd.sym} 51750 210 0 0 {name=s348 lab=VDD}
N 51920 30 51920 10 {lab=VDD}
C {devices/vdd.sym} 51920 10 0 0 {name=s349 lab=VDD}
N 51920 60 51950 60 {lab=VDD}
C {devices/vdd.sym} 51950 60 0 0 {name=s350 lab=VDD}
N 52280 1220 52310 1220 {lab=0}
C {devices/gnd.sym} 52310 1220 0 0 {name=s351 lab=0}
N 52480 1220 52510 1220 {lab=0}
C {devices/gnd.sym} 52510 1220 0 0 {name=s352 lab=0}
N 52280 1400 52280 1420 {lab=0}
C {devices/gnd.sym} 52280 1420 0 0 {name=s353 lab=0}
N 52280 1370 52310 1370 {lab=0}
C {devices/gnd.sym} 52310 1370 0 0 {name=s354 lab=0}
N 52280 30 52280 10 {lab=VDD}
C {devices/vdd.sym} 52280 10 0 0 {name=s355 lab=VDD}
N 52280 60 52310 60 {lab=VDD}
C {devices/vdd.sym} 52310 60 0 0 {name=s356 lab=VDD}
N 52280 210 52310 210 {lab=VDD}
C {devices/vdd.sym} 52310 210 0 0 {name=s357 lab=VDD}
N 52480 30 52480 10 {lab=VDD}
C {devices/vdd.sym} 52480 10 0 0 {name=s358 lab=VDD}
N 52480 60 52510 60 {lab=VDD}
C {devices/vdd.sym} 52510 60 0 0 {name=s359 lab=VDD}
N 52840 1070 52870 1070 {lab=0}
C {devices/gnd.sym} 52870 1070 0 0 {name=s360 lab=0}
N 52840 1220 52870 1220 {lab=0}
C {devices/gnd.sym} 52870 1220 0 0 {name=s361 lab=0}
N 52840 1400 52840 1420 {lab=0}
C {devices/gnd.sym} 52840 1420 0 0 {name=s362 lab=0}
N 52840 1370 52870 1370 {lab=0}
C {devices/gnd.sym} 52870 1370 0 0 {name=s363 lab=0}
N 53600 1400 53600 1420 {lab=0}
C {devices/gnd.sym} 53600 1420 0 0 {name=s364 lab=0}
N 53600 1370 53630 1370 {lab=0}
C {devices/gnd.sym} 53630 1370 0 0 {name=s365 lab=0}
N 52840 30 52840 10 {lab=VDD}
C {devices/vdd.sym} 52840 10 0 0 {name=s366 lab=VDD}
N 52840 60 52870 60 {lab=VDD}
C {devices/vdd.sym} 52870 60 0 0 {name=s367 lab=VDD}
N 53040 30 53040 10 {lab=VDD}
C {devices/vdd.sym} 53040 10 0 0 {name=s368 lab=VDD}
N 53040 60 53070 60 {lab=VDD}
C {devices/vdd.sym} 53070 60 0 0 {name=s369 lab=VDD}
N 53240 30 53240 10 {lab=VDD}
C {devices/vdd.sym} 53240 10 0 0 {name=s370 lab=VDD}
N 53240 60 53270 60 {lab=VDD}
C {devices/vdd.sym} 53270 60 0 0 {name=s371 lab=VDD}
N 53600 30 53600 10 {lab=VDD}
C {devices/vdd.sym} 53600 10 0 0 {name=s372 lab=VDD}
N 53600 60 53630 60 {lab=VDD}
C {devices/vdd.sym} 53630 60 0 0 {name=s373 lab=VDD}
N 53960 1400 53960 1420 {lab=0}
C {devices/gnd.sym} 53960 1420 0 0 {name=s374 lab=0}
N 53960 1370 53990 1370 {lab=0}
C {devices/gnd.sym} 53990 1370 0 0 {name=s375 lab=0}
N 54160 1400 54160 1420 {lab=0}
C {devices/gnd.sym} 54160 1420 0 0 {name=s376 lab=0}
N 54160 1370 54190 1370 {lab=0}
C {devices/gnd.sym} 54190 1370 0 0 {name=s377 lab=0}
N 53960 30 53960 10 {lab=VDD}
C {devices/vdd.sym} 53960 10 0 0 {name=s378 lab=VDD}
N 53960 60 53990 60 {lab=VDD}
C {devices/vdd.sym} 53990 60 0 0 {name=s379 lab=VDD}
N 53960 210 53990 210 {lab=VDD}
C {devices/vdd.sym} 53990 210 0 0 {name=s380 lab=VDD}
N 54520 1400 54520 1420 {lab=0}
C {devices/gnd.sym} 54520 1420 0 0 {name=s381 lab=0}
N 54520 1370 54550 1370 {lab=0}
C {devices/gnd.sym} 54550 1370 0 0 {name=s382 lab=0}
N 54520 1220 54550 1220 {lab=0}
C {devices/gnd.sym} 54550 1220 0 0 {name=s383 lab=0}
N 54520 1070 54550 1070 {lab=0}
C {devices/gnd.sym} 54550 1070 0 0 {name=s384 lab=0}
N 54520 30 54520 10 {lab=VDD}
C {devices/vdd.sym} 54520 10 0 0 {name=s385 lab=VDD}
N 54520 60 54550 60 {lab=VDD}
C {devices/vdd.sym} 54550 60 0 0 {name=s386 lab=VDD}
N 54720 30 54720 10 {lab=VDD}
C {devices/vdd.sym} 54720 10 0 0 {name=s387 lab=VDD}
N 54720 60 54750 60 {lab=VDD}
C {devices/vdd.sym} 54750 60 0 0 {name=s388 lab=VDD}
N 54920 30 54920 10 {lab=VDD}
C {devices/vdd.sym} 54920 10 0 0 {name=s389 lab=VDD}
N 54920 60 54950 60 {lab=VDD}
C {devices/vdd.sym} 54950 60 0 0 {name=s390 lab=VDD}
N 55280 1400 55280 1420 {lab=0}
C {devices/gnd.sym} 55280 1420 0 0 {name=s391 lab=0}
N 55280 1370 55310 1370 {lab=0}
C {devices/gnd.sym} 55310 1370 0 0 {name=s392 lab=0}
N 55280 1220 55310 1220 {lab=0}
C {devices/gnd.sym} 55310 1220 0 0 {name=s393 lab=0}
N 55280 30 55280 10 {lab=VDD}
C {devices/vdd.sym} 55280 10 0 0 {name=s394 lab=VDD}
N 55280 60 55310 60 {lab=VDD}
C {devices/vdd.sym} 55310 60 0 0 {name=s395 lab=VDD}
N 55480 30 55480 10 {lab=VDD}
C {devices/vdd.sym} 55480 10 0 0 {name=s396 lab=VDD}
N 55480 60 55510 60 {lab=VDD}
C {devices/vdd.sym} 55510 60 0 0 {name=s397 lab=VDD}
N 55840 1400 55840 1420 {lab=0}
C {devices/gnd.sym} 55840 1420 0 0 {name=s398 lab=0}
N 55840 1370 55870 1370 {lab=0}
C {devices/gnd.sym} 55870 1370 0 0 {name=s399 lab=0}
N 55840 1220 55870 1220 {lab=0}
C {devices/gnd.sym} 55870 1220 0 0 {name=s400 lab=0}
N 56040 1400 56040 1420 {lab=0}
C {devices/gnd.sym} 56040 1420 0 0 {name=s401 lab=0}
N 56040 1370 56070 1370 {lab=0}
C {devices/gnd.sym} 56070 1370 0 0 {name=s402 lab=0}
N 55840 210 55870 210 {lab=VDD}
C {devices/vdd.sym} 55870 210 0 0 {name=s403 lab=VDD}
N 56040 210 56070 210 {lab=VDD}
C {devices/vdd.sym} 56070 210 0 0 {name=s404 lab=VDD}
N 55840 30 55840 10 {lab=VDD}
C {devices/vdd.sym} 55840 10 0 0 {name=s405 lab=VDD}
N 55840 60 55870 60 {lab=VDD}
C {devices/vdd.sym} 55870 60 0 0 {name=s406 lab=VDD}
N 56400 1400 56400 1420 {lab=0}
C {devices/gnd.sym} 56400 1420 0 0 {name=s407 lab=0}
N 56400 1370 56430 1370 {lab=0}
C {devices/gnd.sym} 56430 1370 0 0 {name=s408 lab=0}
N 56600 1400 56600 1420 {lab=0}
C {devices/gnd.sym} 56600 1420 0 0 {name=s409 lab=0}
N 56600 1370 56630 1370 {lab=0}
C {devices/gnd.sym} 56630 1370 0 0 {name=s410 lab=0}
N 56400 30 56400 10 {lab=VDD}
C {devices/vdd.sym} 56400 10 0 0 {name=s411 lab=VDD}
N 56400 60 56430 60 {lab=VDD}
C {devices/vdd.sym} 56430 60 0 0 {name=s412 lab=VDD}
N 56400 210 56430 210 {lab=VDD}
C {devices/vdd.sym} 56430 210 0 0 {name=s413 lab=VDD}
N 3560 1400 3560 1420 {lab=0}
C {devices/gnd.sym} 3560 1420 0 0 {name=s414 lab=0}
N 3560 1370 3590 1370 {lab=0}
C {devices/gnd.sym} 3590 1370 0 0 {name=s415 lab=0}
N 7520 1400 7520 1420 {lab=0}
C {devices/gnd.sym} 7520 1420 0 0 {name=s416 lab=0}
N 7520 1370 7550 1370 {lab=0}
C {devices/gnd.sym} 7550 1370 0 0 {name=s417 lab=0}
N 17440 1400 17440 1420 {lab=0}
C {devices/gnd.sym} 17440 1420 0 0 {name=s418 lab=0}
N 17440 1370 17470 1370 {lab=0}
C {devices/gnd.sym} 17470 1370 0 0 {name=s419 lab=0}
N 17440 1220 17470 1220 {lab=0}
C {devices/gnd.sym} 17470 1220 0 0 {name=s420 lab=0}
N 17640 1070 17670 1070 {lab=0}
C {devices/gnd.sym} 17670 1070 0 0 {name=s421 lab=0}
N 17640 1220 17670 1220 {lab=0}
C {devices/gnd.sym} 17670 1220 0 0 {name=s422 lab=0}
N 17640 1400 17640 1420 {lab=0}
C {devices/gnd.sym} 17640 1420 0 0 {name=s423 lab=0}
N 17640 1370 17670 1370 {lab=0}
C {devices/gnd.sym} 17670 1370 0 0 {name=s424 lab=0}
N 18760 1400 18760 1420 {lab=0}
C {devices/gnd.sym} 18760 1420 0 0 {name=s425 lab=0}
N 18760 1370 18790 1370 {lab=0}
C {devices/gnd.sym} 18790 1370 0 0 {name=s426 lab=0}
N 18760 1220 18790 1220 {lab=0}
C {devices/gnd.sym} 18790 1220 0 0 {name=s427 lab=0}
N 18960 1220 18990 1220 {lab=0}
C {devices/gnd.sym} 18990 1220 0 0 {name=s428 lab=0}
N 18960 1400 18960 1420 {lab=0}
C {devices/gnd.sym} 18960 1420 0 0 {name=s429 lab=0}
N 18960 1370 18990 1370 {lab=0}
C {devices/gnd.sym} 18990 1370 0 0 {name=s430 lab=0}
N 18200 1400 18200 1420 {lab=0}
C {devices/gnd.sym} 18200 1420 0 0 {name=s431 lab=0}
N 18200 1370 18230 1370 {lab=0}
C {devices/gnd.sym} 18230 1370 0 0 {name=s432 lab=0}
N 18200 1220 18230 1220 {lab=0}
C {devices/gnd.sym} 18230 1220 0 0 {name=s433 lab=0}
N 19320 1400 19320 1420 {lab=0}
C {devices/gnd.sym} 19320 1420 0 0 {name=s434 lab=0}
N 19320 1370 19350 1370 {lab=0}
C {devices/gnd.sym} 19350 1370 0 0 {name=s435 lab=0}
N 3560 30 3560 10 {lab=VDD}
C {devices/vdd.sym} 3560 10 0 0 {name=s436 lab=VDD}
N 3560 60 3590 60 {lab=VDD}
C {devices/vdd.sym} 3590 60 0 0 {name=s437 lab=VDD}
N 7520 30 7520 10 {lab=VDD}
C {devices/vdd.sym} 7520 10 0 0 {name=s438 lab=VDD}
N 7520 60 7550 60 {lab=VDD}
C {devices/vdd.sym} 7550 60 0 0 {name=s439 lab=VDD}
N 17440 30 17440 10 {lab=VDD}
C {devices/vdd.sym} 17440 10 0 0 {name=s440 lab=VDD}
N 17440 60 17470 60 {lab=VDD}
C {devices/vdd.sym} 17470 60 0 0 {name=s441 lab=VDD}
N 17440 210 17470 210 {lab=VDD}
C {devices/vdd.sym} 17470 210 0 0 {name=s442 lab=VDD}
N 17840 210 17870 210 {lab=VDD}
C {devices/vdd.sym} 17870 210 0 0 {name=s443 lab=VDD}
N 17640 30 17640 10 {lab=VDD}
C {devices/vdd.sym} 17640 10 0 0 {name=s444 lab=VDD}
N 17640 60 17670 60 {lab=VDD}
C {devices/vdd.sym} 17670 60 0 0 {name=s445 lab=VDD}
N 17840 30 17840 10 {lab=VDD}
C {devices/vdd.sym} 17840 10 0 0 {name=s446 lab=VDD}
N 17840 60 17870 60 {lab=VDD}
C {devices/vdd.sym} 17870 60 0 0 {name=s447 lab=VDD}
N 18760 30 18760 10 {lab=VDD}
C {devices/vdd.sym} 18760 10 0 0 {name=s448 lab=VDD}
N 18760 60 18790 60 {lab=VDD}
C {devices/vdd.sym} 18790 60 0 0 {name=s449 lab=VDD}
N 18760 210 18790 210 {lab=VDD}
C {devices/vdd.sym} 18790 210 0 0 {name=s450 lab=VDD}
N 18960 210 18990 210 {lab=VDD}
C {devices/vdd.sym} 18990 210 0 0 {name=s451 lab=VDD}
N 18960 30 18960 10 {lab=VDD}
C {devices/vdd.sym} 18960 10 0 0 {name=s452 lab=VDD}
N 18960 60 18990 60 {lab=VDD}
C {devices/vdd.sym} 18990 60 0 0 {name=s453 lab=VDD}
N 18200 30 18200 10 {lab=VDD}
C {devices/vdd.sym} 18200 10 0 0 {name=s454 lab=VDD}
N 18200 60 18230 60 {lab=VDD}
C {devices/vdd.sym} 18230 60 0 0 {name=s455 lab=VDD}
N 18400 30 18400 10 {lab=VDD}
C {devices/vdd.sym} 18400 10 0 0 {name=s456 lab=VDD}
N 18400 60 18430 60 {lab=VDD}
C {devices/vdd.sym} 18430 60 0 0 {name=s457 lab=VDD}
N 19320 30 19320 10 {lab=VDD}
C {devices/vdd.sym} 19320 10 0 0 {name=s458 lab=VDD}
N 19320 60 19350 60 {lab=VDD}
C {devices/vdd.sym} 19350 60 0 0 {name=s459 lab=VDD}
N 3920 1400 3920 1420 {lab=0}
C {devices/gnd.sym} 3920 1420 0 0 {name=s460 lab=0}
N 3920 1370 3950 1370 {lab=0}
C {devices/gnd.sym} 3950 1370 0 0 {name=s461 lab=0}
N 7880 1400 7880 1420 {lab=0}
C {devices/gnd.sym} 7880 1420 0 0 {name=s462 lab=0}
N 7880 1370 7910 1370 {lab=0}
C {devices/gnd.sym} 7910 1370 0 0 {name=s463 lab=0}
N 19680 1400 19680 1420 {lab=0}
C {devices/gnd.sym} 19680 1420 0 0 {name=s464 lab=0}
N 19680 1370 19710 1370 {lab=0}
C {devices/gnd.sym} 19710 1370 0 0 {name=s465 lab=0}
N 19680 1220 19710 1220 {lab=0}
C {devices/gnd.sym} 19710 1220 0 0 {name=s466 lab=0}
N 19880 1070 19910 1070 {lab=0}
C {devices/gnd.sym} 19910 1070 0 0 {name=s467 lab=0}
N 19880 1220 19910 1220 {lab=0}
C {devices/gnd.sym} 19910 1220 0 0 {name=s468 lab=0}
N 19880 1400 19880 1420 {lab=0}
C {devices/gnd.sym} 19880 1420 0 0 {name=s469 lab=0}
N 19880 1370 19910 1370 {lab=0}
C {devices/gnd.sym} 19910 1370 0 0 {name=s470 lab=0}
N 21000 1400 21000 1420 {lab=0}
C {devices/gnd.sym} 21000 1420 0 0 {name=s471 lab=0}
N 21000 1370 21030 1370 {lab=0}
C {devices/gnd.sym} 21030 1370 0 0 {name=s472 lab=0}
N 21000 1220 21030 1220 {lab=0}
C {devices/gnd.sym} 21030 1220 0 0 {name=s473 lab=0}
N 21200 1220 21230 1220 {lab=0}
C {devices/gnd.sym} 21230 1220 0 0 {name=s474 lab=0}
N 21200 1400 21200 1420 {lab=0}
C {devices/gnd.sym} 21200 1420 0 0 {name=s475 lab=0}
N 21200 1370 21230 1370 {lab=0}
C {devices/gnd.sym} 21230 1370 0 0 {name=s476 lab=0}
N 20440 1400 20440 1420 {lab=0}
C {devices/gnd.sym} 20440 1420 0 0 {name=s477 lab=0}
N 20440 1370 20470 1370 {lab=0}
C {devices/gnd.sym} 20470 1370 0 0 {name=s478 lab=0}
N 20440 1220 20470 1220 {lab=0}
C {devices/gnd.sym} 20470 1220 0 0 {name=s479 lab=0}
N 21560 1400 21560 1420 {lab=0}
C {devices/gnd.sym} 21560 1420 0 0 {name=s480 lab=0}
N 21560 1370 21590 1370 {lab=0}
C {devices/gnd.sym} 21590 1370 0 0 {name=s481 lab=0}
N 3920 30 3920 10 {lab=VDD}
C {devices/vdd.sym} 3920 10 0 0 {name=s482 lab=VDD}
N 3920 60 3950 60 {lab=VDD}
C {devices/vdd.sym} 3950 60 0 0 {name=s483 lab=VDD}
N 7880 30 7880 10 {lab=VDD}
C {devices/vdd.sym} 7880 10 0 0 {name=s484 lab=VDD}
N 7880 60 7910 60 {lab=VDD}
C {devices/vdd.sym} 7910 60 0 0 {name=s485 lab=VDD}
N 19680 30 19680 10 {lab=VDD}
C {devices/vdd.sym} 19680 10 0 0 {name=s486 lab=VDD}
N 19680 60 19710 60 {lab=VDD}
C {devices/vdd.sym} 19710 60 0 0 {name=s487 lab=VDD}
N 19680 210 19710 210 {lab=VDD}
C {devices/vdd.sym} 19710 210 0 0 {name=s488 lab=VDD}
N 20080 210 20110 210 {lab=VDD}
C {devices/vdd.sym} 20110 210 0 0 {name=s489 lab=VDD}
N 19880 30 19880 10 {lab=VDD}
C {devices/vdd.sym} 19880 10 0 0 {name=s490 lab=VDD}
N 19880 60 19910 60 {lab=VDD}
C {devices/vdd.sym} 19910 60 0 0 {name=s491 lab=VDD}
N 20080 30 20080 10 {lab=VDD}
C {devices/vdd.sym} 20080 10 0 0 {name=s492 lab=VDD}
N 20080 60 20110 60 {lab=VDD}
C {devices/vdd.sym} 20110 60 0 0 {name=s493 lab=VDD}
N 21000 30 21000 10 {lab=VDD}
C {devices/vdd.sym} 21000 10 0 0 {name=s494 lab=VDD}
N 21000 60 21030 60 {lab=VDD}
C {devices/vdd.sym} 21030 60 0 0 {name=s495 lab=VDD}
N 21000 210 21030 210 {lab=VDD}
C {devices/vdd.sym} 21030 210 0 0 {name=s496 lab=VDD}
N 21200 210 21230 210 {lab=VDD}
C {devices/vdd.sym} 21230 210 0 0 {name=s497 lab=VDD}
N 21200 30 21200 10 {lab=VDD}
C {devices/vdd.sym} 21200 10 0 0 {name=s498 lab=VDD}
N 21200 60 21230 60 {lab=VDD}
C {devices/vdd.sym} 21230 60 0 0 {name=s499 lab=VDD}
N 20440 30 20440 10 {lab=VDD}
C {devices/vdd.sym} 20440 10 0 0 {name=s500 lab=VDD}
N 20440 60 20470 60 {lab=VDD}
C {devices/vdd.sym} 20470 60 0 0 {name=s501 lab=VDD}
N 20640 30 20640 10 {lab=VDD}
C {devices/vdd.sym} 20640 10 0 0 {name=s502 lab=VDD}
N 20640 60 20670 60 {lab=VDD}
C {devices/vdd.sym} 20670 60 0 0 {name=s503 lab=VDD}
N 21560 30 21560 10 {lab=VDD}
C {devices/vdd.sym} 21560 10 0 0 {name=s504 lab=VDD}
N 21560 60 21590 60 {lab=VDD}
C {devices/vdd.sym} 21590 60 0 0 {name=s505 lab=VDD}
N 4280 1400 4280 1420 {lab=0}
C {devices/gnd.sym} 4280 1420 0 0 {name=s506 lab=0}
N 4280 1370 4310 1370 {lab=0}
C {devices/gnd.sym} 4310 1370 0 0 {name=s507 lab=0}
N 8240 1400 8240 1420 {lab=0}
C {devices/gnd.sym} 8240 1420 0 0 {name=s508 lab=0}
N 8240 1370 8270 1370 {lab=0}
C {devices/gnd.sym} 8270 1370 0 0 {name=s509 lab=0}
N 12200 1400 12200 1420 {lab=0}
C {devices/gnd.sym} 12200 1420 0 0 {name=s510 lab=0}
N 12200 1370 12230 1370 {lab=0}
C {devices/gnd.sym} 12230 1370 0 0 {name=s511 lab=0}
N 12200 1220 12230 1220 {lab=0}
C {devices/gnd.sym} 12230 1220 0 0 {name=s512 lab=0}
N 12400 1070 12430 1070 {lab=0}
C {devices/gnd.sym} 12430 1070 0 0 {name=s513 lab=0}
N 12400 1220 12430 1220 {lab=0}
C {devices/gnd.sym} 12430 1220 0 0 {name=s514 lab=0}
N 12400 1400 12400 1420 {lab=0}
C {devices/gnd.sym} 12400 1420 0 0 {name=s515 lab=0}
N 12400 1370 12430 1370 {lab=0}
C {devices/gnd.sym} 12430 1370 0 0 {name=s516 lab=0}
N 22480 1400 22480 1420 {lab=0}
C {devices/gnd.sym} 22480 1420 0 0 {name=s517 lab=0}
N 22480 1370 22510 1370 {lab=0}
C {devices/gnd.sym} 22510 1370 0 0 {name=s518 lab=0}
N 22480 1220 22510 1220 {lab=0}
C {devices/gnd.sym} 22510 1220 0 0 {name=s519 lab=0}
N 22680 1220 22710 1220 {lab=0}
C {devices/gnd.sym} 22710 1220 0 0 {name=s520 lab=0}
N 22680 1400 22680 1420 {lab=0}
C {devices/gnd.sym} 22680 1420 0 0 {name=s521 lab=0}
N 22680 1370 22710 1370 {lab=0}
C {devices/gnd.sym} 22710 1370 0 0 {name=s522 lab=0}
N 21920 1400 21920 1420 {lab=0}
C {devices/gnd.sym} 21920 1420 0 0 {name=s523 lab=0}
N 21920 1370 21950 1370 {lab=0}
C {devices/gnd.sym} 21950 1370 0 0 {name=s524 lab=0}
N 21920 1220 21950 1220 {lab=0}
C {devices/gnd.sym} 21950 1220 0 0 {name=s525 lab=0}
N 23040 1400 23040 1420 {lab=0}
C {devices/gnd.sym} 23040 1420 0 0 {name=s526 lab=0}
N 23040 1370 23070 1370 {lab=0}
C {devices/gnd.sym} 23070 1370 0 0 {name=s527 lab=0}
N 4280 30 4280 10 {lab=VDD}
C {devices/vdd.sym} 4280 10 0 0 {name=s528 lab=VDD}
N 4280 60 4310 60 {lab=VDD}
C {devices/vdd.sym} 4310 60 0 0 {name=s529 lab=VDD}
N 8240 30 8240 10 {lab=VDD}
C {devices/vdd.sym} 8240 10 0 0 {name=s530 lab=VDD}
N 8240 60 8270 60 {lab=VDD}
C {devices/vdd.sym} 8270 60 0 0 {name=s531 lab=VDD}
N 12200 30 12200 10 {lab=VDD}
C {devices/vdd.sym} 12200 10 0 0 {name=s532 lab=VDD}
N 12200 60 12230 60 {lab=VDD}
C {devices/vdd.sym} 12230 60 0 0 {name=s533 lab=VDD}
N 12200 210 12230 210 {lab=VDD}
C {devices/vdd.sym} 12230 210 0 0 {name=s534 lab=VDD}
N 12600 210 12630 210 {lab=VDD}
C {devices/vdd.sym} 12630 210 0 0 {name=s535 lab=VDD}
N 12400 30 12400 10 {lab=VDD}
C {devices/vdd.sym} 12400 10 0 0 {name=s536 lab=VDD}
N 12400 60 12430 60 {lab=VDD}
C {devices/vdd.sym} 12430 60 0 0 {name=s537 lab=VDD}
N 12600 30 12600 10 {lab=VDD}
C {devices/vdd.sym} 12600 10 0 0 {name=s538 lab=VDD}
N 12600 60 12630 60 {lab=VDD}
C {devices/vdd.sym} 12630 60 0 0 {name=s539 lab=VDD}
N 22480 30 22480 10 {lab=VDD}
C {devices/vdd.sym} 22480 10 0 0 {name=s540 lab=VDD}
N 22480 60 22510 60 {lab=VDD}
C {devices/vdd.sym} 22510 60 0 0 {name=s541 lab=VDD}
N 22480 210 22510 210 {lab=VDD}
C {devices/vdd.sym} 22510 210 0 0 {name=s542 lab=VDD}
N 22680 210 22710 210 {lab=VDD}
C {devices/vdd.sym} 22710 210 0 0 {name=s543 lab=VDD}
N 22680 30 22680 10 {lab=VDD}
C {devices/vdd.sym} 22680 10 0 0 {name=s544 lab=VDD}
N 22680 60 22710 60 {lab=VDD}
C {devices/vdd.sym} 22710 60 0 0 {name=s545 lab=VDD}
N 21920 30 21920 10 {lab=VDD}
C {devices/vdd.sym} 21920 10 0 0 {name=s546 lab=VDD}
N 21920 60 21950 60 {lab=VDD}
C {devices/vdd.sym} 21950 60 0 0 {name=s547 lab=VDD}
N 22120 30 22120 10 {lab=VDD}
C {devices/vdd.sym} 22120 10 0 0 {name=s548 lab=VDD}
N 22120 60 22150 60 {lab=VDD}
C {devices/vdd.sym} 22150 60 0 0 {name=s549 lab=VDD}
N 23040 30 23040 10 {lab=VDD}
C {devices/vdd.sym} 23040 10 0 0 {name=s550 lab=VDD}
N 23040 60 23070 60 {lab=VDD}
C {devices/vdd.sym} 23070 60 0 0 {name=s551 lab=VDD}
N 4640 1400 4640 1420 {lab=0}
C {devices/gnd.sym} 4640 1420 0 0 {name=s552 lab=0}
N 4640 1370 4670 1370 {lab=0}
C {devices/gnd.sym} 4670 1370 0 0 {name=s553 lab=0}
N 8600 1400 8600 1420 {lab=0}
C {devices/gnd.sym} 8600 1420 0 0 {name=s554 lab=0}
N 8600 1370 8630 1370 {lab=0}
C {devices/gnd.sym} 8630 1370 0 0 {name=s555 lab=0}
N 23400 1400 23400 1420 {lab=0}
C {devices/gnd.sym} 23400 1420 0 0 {name=s556 lab=0}
N 23400 1370 23430 1370 {lab=0}
C {devices/gnd.sym} 23430 1370 0 0 {name=s557 lab=0}
N 23400 1220 23430 1220 {lab=0}
C {devices/gnd.sym} 23430 1220 0 0 {name=s558 lab=0}
N 23600 1070 23630 1070 {lab=0}
C {devices/gnd.sym} 23630 1070 0 0 {name=s559 lab=0}
N 23600 1220 23630 1220 {lab=0}
C {devices/gnd.sym} 23630 1220 0 0 {name=s560 lab=0}
N 23600 1400 23600 1420 {lab=0}
C {devices/gnd.sym} 23600 1420 0 0 {name=s561 lab=0}
N 23600 1370 23630 1370 {lab=0}
C {devices/gnd.sym} 23630 1370 0 0 {name=s562 lab=0}
N 24720 1400 24720 1420 {lab=0}
C {devices/gnd.sym} 24720 1420 0 0 {name=s563 lab=0}
N 24720 1370 24750 1370 {lab=0}
C {devices/gnd.sym} 24750 1370 0 0 {name=s564 lab=0}
N 24720 1220 24750 1220 {lab=0}
C {devices/gnd.sym} 24750 1220 0 0 {name=s565 lab=0}
N 24920 1220 24950 1220 {lab=0}
C {devices/gnd.sym} 24950 1220 0 0 {name=s566 lab=0}
N 24920 1400 24920 1420 {lab=0}
C {devices/gnd.sym} 24920 1420 0 0 {name=s567 lab=0}
N 24920 1370 24950 1370 {lab=0}
C {devices/gnd.sym} 24950 1370 0 0 {name=s568 lab=0}
N 24160 1400 24160 1420 {lab=0}
C {devices/gnd.sym} 24160 1420 0 0 {name=s569 lab=0}
N 24160 1370 24190 1370 {lab=0}
C {devices/gnd.sym} 24190 1370 0 0 {name=s570 lab=0}
N 24160 1220 24190 1220 {lab=0}
C {devices/gnd.sym} 24190 1220 0 0 {name=s571 lab=0}
N 25280 1400 25280 1420 {lab=0}
C {devices/gnd.sym} 25280 1420 0 0 {name=s572 lab=0}
N 25280 1370 25310 1370 {lab=0}
C {devices/gnd.sym} 25310 1370 0 0 {name=s573 lab=0}
N 4640 30 4640 10 {lab=VDD}
C {devices/vdd.sym} 4640 10 0 0 {name=s574 lab=VDD}
N 4640 60 4670 60 {lab=VDD}
C {devices/vdd.sym} 4670 60 0 0 {name=s575 lab=VDD}
N 8600 30 8600 10 {lab=VDD}
C {devices/vdd.sym} 8600 10 0 0 {name=s576 lab=VDD}
N 8600 60 8630 60 {lab=VDD}
C {devices/vdd.sym} 8630 60 0 0 {name=s577 lab=VDD}
N 23400 30 23400 10 {lab=VDD}
C {devices/vdd.sym} 23400 10 0 0 {name=s578 lab=VDD}
N 23400 60 23430 60 {lab=VDD}
C {devices/vdd.sym} 23430 60 0 0 {name=s579 lab=VDD}
N 23400 210 23430 210 {lab=VDD}
C {devices/vdd.sym} 23430 210 0 0 {name=s580 lab=VDD}
N 23800 210 23830 210 {lab=VDD}
C {devices/vdd.sym} 23830 210 0 0 {name=s581 lab=VDD}
N 23600 30 23600 10 {lab=VDD}
C {devices/vdd.sym} 23600 10 0 0 {name=s582 lab=VDD}
N 23600 60 23630 60 {lab=VDD}
C {devices/vdd.sym} 23630 60 0 0 {name=s583 lab=VDD}
N 23800 30 23800 10 {lab=VDD}
C {devices/vdd.sym} 23800 10 0 0 {name=s584 lab=VDD}
N 23800 60 23830 60 {lab=VDD}
C {devices/vdd.sym} 23830 60 0 0 {name=s585 lab=VDD}
N 24720 30 24720 10 {lab=VDD}
C {devices/vdd.sym} 24720 10 0 0 {name=s586 lab=VDD}
N 24720 60 24750 60 {lab=VDD}
C {devices/vdd.sym} 24750 60 0 0 {name=s587 lab=VDD}
N 24720 210 24750 210 {lab=VDD}
C {devices/vdd.sym} 24750 210 0 0 {name=s588 lab=VDD}
N 24920 210 24950 210 {lab=VDD}
C {devices/vdd.sym} 24950 210 0 0 {name=s589 lab=VDD}
N 24920 30 24920 10 {lab=VDD}
C {devices/vdd.sym} 24920 10 0 0 {name=s590 lab=VDD}
N 24920 60 24950 60 {lab=VDD}
C {devices/vdd.sym} 24950 60 0 0 {name=s591 lab=VDD}
N 24160 30 24160 10 {lab=VDD}
C {devices/vdd.sym} 24160 10 0 0 {name=s592 lab=VDD}
N 24160 60 24190 60 {lab=VDD}
C {devices/vdd.sym} 24190 60 0 0 {name=s593 lab=VDD}
N 24360 30 24360 10 {lab=VDD}
C {devices/vdd.sym} 24360 10 0 0 {name=s594 lab=VDD}
N 24360 60 24390 60 {lab=VDD}
C {devices/vdd.sym} 24390 60 0 0 {name=s595 lab=VDD}
N 25280 30 25280 10 {lab=VDD}
C {devices/vdd.sym} 25280 10 0 0 {name=s596 lab=VDD}
N 25280 60 25310 60 {lab=VDD}
C {devices/vdd.sym} 25310 60 0 0 {name=s597 lab=VDD}
N 5000 1400 5000 1420 {lab=0}
C {devices/gnd.sym} 5000 1420 0 0 {name=s598 lab=0}
N 5000 1370 5030 1370 {lab=0}
C {devices/gnd.sym} 5030 1370 0 0 {name=s599 lab=0}
N 8960 1400 8960 1420 {lab=0}
C {devices/gnd.sym} 8960 1420 0 0 {name=s600 lab=0}
N 8960 1370 8990 1370 {lab=0}
C {devices/gnd.sym} 8990 1370 0 0 {name=s601 lab=0}
N 25640 1400 25640 1420 {lab=0}
C {devices/gnd.sym} 25640 1420 0 0 {name=s602 lab=0}
N 25640 1370 25670 1370 {lab=0}
C {devices/gnd.sym} 25670 1370 0 0 {name=s603 lab=0}
N 25640 1220 25670 1220 {lab=0}
C {devices/gnd.sym} 25670 1220 0 0 {name=s604 lab=0}
N 25840 1070 25870 1070 {lab=0}
C {devices/gnd.sym} 25870 1070 0 0 {name=s605 lab=0}
N 25840 1220 25870 1220 {lab=0}
C {devices/gnd.sym} 25870 1220 0 0 {name=s606 lab=0}
N 25840 1400 25840 1420 {lab=0}
C {devices/gnd.sym} 25840 1420 0 0 {name=s607 lab=0}
N 25840 1370 25870 1370 {lab=0}
C {devices/gnd.sym} 25870 1370 0 0 {name=s608 lab=0}
N 26960 1400 26960 1420 {lab=0}
C {devices/gnd.sym} 26960 1420 0 0 {name=s609 lab=0}
N 26960 1370 26990 1370 {lab=0}
C {devices/gnd.sym} 26990 1370 0 0 {name=s610 lab=0}
N 26960 1220 26990 1220 {lab=0}
C {devices/gnd.sym} 26990 1220 0 0 {name=s611 lab=0}
N 27160 1220 27190 1220 {lab=0}
C {devices/gnd.sym} 27190 1220 0 0 {name=s612 lab=0}
N 27160 1400 27160 1420 {lab=0}
C {devices/gnd.sym} 27160 1420 0 0 {name=s613 lab=0}
N 27160 1370 27190 1370 {lab=0}
C {devices/gnd.sym} 27190 1370 0 0 {name=s614 lab=0}
N 26400 1400 26400 1420 {lab=0}
C {devices/gnd.sym} 26400 1420 0 0 {name=s615 lab=0}
N 26400 1370 26430 1370 {lab=0}
C {devices/gnd.sym} 26430 1370 0 0 {name=s616 lab=0}
N 26400 1220 26430 1220 {lab=0}
C {devices/gnd.sym} 26430 1220 0 0 {name=s617 lab=0}
N 27520 1400 27520 1420 {lab=0}
C {devices/gnd.sym} 27520 1420 0 0 {name=s618 lab=0}
N 27520 1370 27550 1370 {lab=0}
C {devices/gnd.sym} 27550 1370 0 0 {name=s619 lab=0}
N 5000 30 5000 10 {lab=VDD}
C {devices/vdd.sym} 5000 10 0 0 {name=s620 lab=VDD}
N 5000 60 5030 60 {lab=VDD}
C {devices/vdd.sym} 5030 60 0 0 {name=s621 lab=VDD}
N 8960 30 8960 10 {lab=VDD}
C {devices/vdd.sym} 8960 10 0 0 {name=s622 lab=VDD}
N 8960 60 8990 60 {lab=VDD}
C {devices/vdd.sym} 8990 60 0 0 {name=s623 lab=VDD}
N 25640 30 25640 10 {lab=VDD}
C {devices/vdd.sym} 25640 10 0 0 {name=s624 lab=VDD}
N 25640 60 25670 60 {lab=VDD}
C {devices/vdd.sym} 25670 60 0 0 {name=s625 lab=VDD}
N 25640 210 25670 210 {lab=VDD}
C {devices/vdd.sym} 25670 210 0 0 {name=s626 lab=VDD}
N 26040 210 26070 210 {lab=VDD}
C {devices/vdd.sym} 26070 210 0 0 {name=s627 lab=VDD}
N 25840 30 25840 10 {lab=VDD}
C {devices/vdd.sym} 25840 10 0 0 {name=s628 lab=VDD}
N 25840 60 25870 60 {lab=VDD}
C {devices/vdd.sym} 25870 60 0 0 {name=s629 lab=VDD}
N 26040 30 26040 10 {lab=VDD}
C {devices/vdd.sym} 26040 10 0 0 {name=s630 lab=VDD}
N 26040 60 26070 60 {lab=VDD}
C {devices/vdd.sym} 26070 60 0 0 {name=s631 lab=VDD}
N 26960 30 26960 10 {lab=VDD}
C {devices/vdd.sym} 26960 10 0 0 {name=s632 lab=VDD}
N 26960 60 26990 60 {lab=VDD}
C {devices/vdd.sym} 26990 60 0 0 {name=s633 lab=VDD}
N 26960 210 26990 210 {lab=VDD}
C {devices/vdd.sym} 26990 210 0 0 {name=s634 lab=VDD}
N 27160 210 27190 210 {lab=VDD}
C {devices/vdd.sym} 27190 210 0 0 {name=s635 lab=VDD}
N 27160 30 27160 10 {lab=VDD}
C {devices/vdd.sym} 27160 10 0 0 {name=s636 lab=VDD}
N 27160 60 27190 60 {lab=VDD}
C {devices/vdd.sym} 27190 60 0 0 {name=s637 lab=VDD}
N 26400 30 26400 10 {lab=VDD}
C {devices/vdd.sym} 26400 10 0 0 {name=s638 lab=VDD}
N 26400 60 26430 60 {lab=VDD}
C {devices/vdd.sym} 26430 60 0 0 {name=s639 lab=VDD}
N 26600 30 26600 10 {lab=VDD}
C {devices/vdd.sym} 26600 10 0 0 {name=s640 lab=VDD}
N 26600 60 26630 60 {lab=VDD}
C {devices/vdd.sym} 26630 60 0 0 {name=s641 lab=VDD}
N 27520 30 27520 10 {lab=VDD}
C {devices/vdd.sym} 27520 10 0 0 {name=s642 lab=VDD}
N 27520 60 27550 60 {lab=VDD}
C {devices/vdd.sym} 27550 60 0 0 {name=s643 lab=VDD}
N 5360 1400 5360 1420 {lab=0}
C {devices/gnd.sym} 5360 1420 0 0 {name=s644 lab=0}
N 5360 1370 5390 1370 {lab=0}
C {devices/gnd.sym} 5390 1370 0 0 {name=s645 lab=0}
N 9320 1400 9320 1420 {lab=0}
C {devices/gnd.sym} 9320 1420 0 0 {name=s646 lab=0}
N 9320 1370 9350 1370 {lab=0}
C {devices/gnd.sym} 9350 1370 0 0 {name=s647 lab=0}
N 56960 1400 56960 1420 {lab=0}
C {devices/gnd.sym} 56960 1420 0 0 {name=s648 lab=0}
N 56960 1370 56990 1370 {lab=0}
C {devices/gnd.sym} 56990 1370 0 0 {name=s649 lab=0}
N 56960 1220 56990 1220 {lab=0}
C {devices/gnd.sym} 56990 1220 0 0 {name=s650 lab=0}
N 57160 1070 57190 1070 {lab=0}
C {devices/gnd.sym} 57190 1070 0 0 {name=s651 lab=0}
N 57160 1220 57190 1220 {lab=0}
C {devices/gnd.sym} 57190 1220 0 0 {name=s652 lab=0}
N 57160 1400 57160 1420 {lab=0}
C {devices/gnd.sym} 57160 1420 0 0 {name=s653 lab=0}
N 57160 1370 57190 1370 {lab=0}
C {devices/gnd.sym} 57190 1370 0 0 {name=s654 lab=0}
N 57720 1400 57720 1420 {lab=0}
C {devices/gnd.sym} 57720 1420 0 0 {name=s655 lab=0}
N 57720 1370 57750 1370 {lab=0}
C {devices/gnd.sym} 57750 1370 0 0 {name=s656 lab=0}
N 57720 1220 57750 1220 {lab=0}
C {devices/gnd.sym} 57750 1220 0 0 {name=s657 lab=0}
N 57920 1220 57950 1220 {lab=0}
C {devices/gnd.sym} 57950 1220 0 0 {name=s658 lab=0}
N 57920 1400 57920 1420 {lab=0}
C {devices/gnd.sym} 57920 1420 0 0 {name=s659 lab=0}
N 57920 1370 57950 1370 {lab=0}
C {devices/gnd.sym} 57950 1370 0 0 {name=s660 lab=0}
N 28240 1400 28240 1420 {lab=0}
C {devices/gnd.sym} 28240 1420 0 0 {name=s661 lab=0}
N 28240 1370 28270 1370 {lab=0}
C {devices/gnd.sym} 28270 1370 0 0 {name=s662 lab=0}
N 28240 1220 28270 1220 {lab=0}
C {devices/gnd.sym} 28270 1220 0 0 {name=s663 lab=0}
N 28800 1400 28800 1420 {lab=0}
C {devices/gnd.sym} 28800 1420 0 0 {name=s664 lab=0}
N 28800 1370 28830 1370 {lab=0}
C {devices/gnd.sym} 28830 1370 0 0 {name=s665 lab=0}
N 5360 30 5360 10 {lab=VDD}
C {devices/vdd.sym} 5360 10 0 0 {name=s666 lab=VDD}
N 5360 60 5390 60 {lab=VDD}
C {devices/vdd.sym} 5390 60 0 0 {name=s667 lab=VDD}
N 9320 30 9320 10 {lab=VDD}
C {devices/vdd.sym} 9320 10 0 0 {name=s668 lab=VDD}
N 9320 60 9350 60 {lab=VDD}
C {devices/vdd.sym} 9350 60 0 0 {name=s669 lab=VDD}
N 56960 30 56960 10 {lab=VDD}
C {devices/vdd.sym} 56960 10 0 0 {name=s670 lab=VDD}
N 56960 60 56990 60 {lab=VDD}
C {devices/vdd.sym} 56990 60 0 0 {name=s671 lab=VDD}
N 56960 210 56990 210 {lab=VDD}
C {devices/vdd.sym} 56990 210 0 0 {name=s672 lab=VDD}
N 57360 210 57390 210 {lab=VDD}
C {devices/vdd.sym} 57390 210 0 0 {name=s673 lab=VDD}
N 57160 30 57160 10 {lab=VDD}
C {devices/vdd.sym} 57160 10 0 0 {name=s674 lab=VDD}
N 57160 60 57190 60 {lab=VDD}
C {devices/vdd.sym} 57190 60 0 0 {name=s675 lab=VDD}
N 57360 30 57360 10 {lab=VDD}
C {devices/vdd.sym} 57360 10 0 0 {name=s676 lab=VDD}
N 57360 60 57390 60 {lab=VDD}
C {devices/vdd.sym} 57390 60 0 0 {name=s677 lab=VDD}
N 57720 30 57720 10 {lab=VDD}
C {devices/vdd.sym} 57720 10 0 0 {name=s678 lab=VDD}
N 57720 60 57750 60 {lab=VDD}
C {devices/vdd.sym} 57750 60 0 0 {name=s679 lab=VDD}
N 57720 210 57750 210 {lab=VDD}
C {devices/vdd.sym} 57750 210 0 0 {name=s680 lab=VDD}
N 57920 210 57950 210 {lab=VDD}
C {devices/vdd.sym} 57950 210 0 0 {name=s681 lab=VDD}
N 57920 30 57920 10 {lab=VDD}
C {devices/vdd.sym} 57920 10 0 0 {name=s682 lab=VDD}
N 57920 60 57950 60 {lab=VDD}
C {devices/vdd.sym} 57950 60 0 0 {name=s683 lab=VDD}
N 28240 30 28240 10 {lab=VDD}
C {devices/vdd.sym} 28240 10 0 0 {name=s684 lab=VDD}
N 28240 60 28270 60 {lab=VDD}
C {devices/vdd.sym} 28270 60 0 0 {name=s685 lab=VDD}
N 28440 30 28440 10 {lab=VDD}
C {devices/vdd.sym} 28440 10 0 0 {name=s686 lab=VDD}
N 28440 60 28470 60 {lab=VDD}
C {devices/vdd.sym} 28470 60 0 0 {name=s687 lab=VDD}
N 28800 30 28800 10 {lab=VDD}
C {devices/vdd.sym} 28800 10 0 0 {name=s688 lab=VDD}
N 28800 60 28830 60 {lab=VDD}
C {devices/vdd.sym} 28830 60 0 0 {name=s689 lab=VDD}
N 5720 1400 5720 1420 {lab=0}
C {devices/gnd.sym} 5720 1420 0 0 {name=s690 lab=0}
N 5720 1370 5750 1370 {lab=0}
C {devices/gnd.sym} 5750 1370 0 0 {name=s691 lab=0}
N 9680 1400 9680 1420 {lab=0}
C {devices/gnd.sym} 9680 1420 0 0 {name=s692 lab=0}
N 9680 1370 9710 1370 {lab=0}
C {devices/gnd.sym} 9710 1370 0 0 {name=s693 lab=0}
N 58280 1400 58280 1420 {lab=0}
C {devices/gnd.sym} 58280 1420 0 0 {name=s694 lab=0}
N 58280 1370 58310 1370 {lab=0}
C {devices/gnd.sym} 58310 1370 0 0 {name=s695 lab=0}
N 58280 1220 58310 1220 {lab=0}
C {devices/gnd.sym} 58310 1220 0 0 {name=s696 lab=0}
N 58480 1070 58510 1070 {lab=0}
C {devices/gnd.sym} 58510 1070 0 0 {name=s697 lab=0}
N 58480 1220 58510 1220 {lab=0}
C {devices/gnd.sym} 58510 1220 0 0 {name=s698 lab=0}
N 58480 1400 58480 1420 {lab=0}
C {devices/gnd.sym} 58480 1420 0 0 {name=s699 lab=0}
N 58480 1370 58510 1370 {lab=0}
C {devices/gnd.sym} 58510 1370 0 0 {name=s700 lab=0}
N 59040 1400 59040 1420 {lab=0}
C {devices/gnd.sym} 59040 1420 0 0 {name=s701 lab=0}
N 59040 1370 59070 1370 {lab=0}
C {devices/gnd.sym} 59070 1370 0 0 {name=s702 lab=0}
N 59040 1220 59070 1220 {lab=0}
C {devices/gnd.sym} 59070 1220 0 0 {name=s703 lab=0}
N 59240 1220 59270 1220 {lab=0}
C {devices/gnd.sym} 59270 1220 0 0 {name=s704 lab=0}
N 59240 1400 59240 1420 {lab=0}
C {devices/gnd.sym} 59240 1420 0 0 {name=s705 lab=0}
N 59240 1370 59270 1370 {lab=0}
C {devices/gnd.sym} 59270 1370 0 0 {name=s706 lab=0}
N 29520 1400 29520 1420 {lab=0}
C {devices/gnd.sym} 29520 1420 0 0 {name=s707 lab=0}
N 29520 1370 29550 1370 {lab=0}
C {devices/gnd.sym} 29550 1370 0 0 {name=s708 lab=0}
N 29520 1220 29550 1220 {lab=0}
C {devices/gnd.sym} 29550 1220 0 0 {name=s709 lab=0}
N 30080 1400 30080 1420 {lab=0}
C {devices/gnd.sym} 30080 1420 0 0 {name=s710 lab=0}
N 30080 1370 30110 1370 {lab=0}
C {devices/gnd.sym} 30110 1370 0 0 {name=s711 lab=0}
N 5720 30 5720 10 {lab=VDD}
C {devices/vdd.sym} 5720 10 0 0 {name=s712 lab=VDD}
N 5720 60 5750 60 {lab=VDD}
C {devices/vdd.sym} 5750 60 0 0 {name=s713 lab=VDD}
N 9680 30 9680 10 {lab=VDD}
C {devices/vdd.sym} 9680 10 0 0 {name=s714 lab=VDD}
N 9680 60 9710 60 {lab=VDD}
C {devices/vdd.sym} 9710 60 0 0 {name=s715 lab=VDD}
N 58280 30 58280 10 {lab=VDD}
C {devices/vdd.sym} 58280 10 0 0 {name=s716 lab=VDD}
N 58280 60 58310 60 {lab=VDD}
C {devices/vdd.sym} 58310 60 0 0 {name=s717 lab=VDD}
N 58280 210 58310 210 {lab=VDD}
C {devices/vdd.sym} 58310 210 0 0 {name=s718 lab=VDD}
N 58680 210 58710 210 {lab=VDD}
C {devices/vdd.sym} 58710 210 0 0 {name=s719 lab=VDD}
N 58480 30 58480 10 {lab=VDD}
C {devices/vdd.sym} 58480 10 0 0 {name=s720 lab=VDD}
N 58480 60 58510 60 {lab=VDD}
C {devices/vdd.sym} 58510 60 0 0 {name=s721 lab=VDD}
N 58680 30 58680 10 {lab=VDD}
C {devices/vdd.sym} 58680 10 0 0 {name=s722 lab=VDD}
N 58680 60 58710 60 {lab=VDD}
C {devices/vdd.sym} 58710 60 0 0 {name=s723 lab=VDD}
N 59040 30 59040 10 {lab=VDD}
C {devices/vdd.sym} 59040 10 0 0 {name=s724 lab=VDD}
N 59040 60 59070 60 {lab=VDD}
C {devices/vdd.sym} 59070 60 0 0 {name=s725 lab=VDD}
N 59040 210 59070 210 {lab=VDD}
C {devices/vdd.sym} 59070 210 0 0 {name=s726 lab=VDD}
N 59240 210 59270 210 {lab=VDD}
C {devices/vdd.sym} 59270 210 0 0 {name=s727 lab=VDD}
N 59240 30 59240 10 {lab=VDD}
C {devices/vdd.sym} 59240 10 0 0 {name=s728 lab=VDD}
N 59240 60 59270 60 {lab=VDD}
C {devices/vdd.sym} 59270 60 0 0 {name=s729 lab=VDD}
N 29520 30 29520 10 {lab=VDD}
C {devices/vdd.sym} 29520 10 0 0 {name=s730 lab=VDD}
N 29520 60 29550 60 {lab=VDD}
C {devices/vdd.sym} 29550 60 0 0 {name=s731 lab=VDD}
N 29720 30 29720 10 {lab=VDD}
C {devices/vdd.sym} 29720 10 0 0 {name=s732 lab=VDD}
N 29720 60 29750 60 {lab=VDD}
C {devices/vdd.sym} 29750 60 0 0 {name=s733 lab=VDD}
N 30080 30 30080 10 {lab=VDD}
C {devices/vdd.sym} 30080 10 0 0 {name=s734 lab=VDD}
N 30080 60 30110 60 {lab=VDD}
C {devices/vdd.sym} 30110 60 0 0 {name=s735 lab=VDD}
N 6080 1400 6080 1420 {lab=0}
C {devices/gnd.sym} 6080 1420 0 0 {name=s736 lab=0}
N 6080 1370 6110 1370 {lab=0}
C {devices/gnd.sym} 6110 1370 0 0 {name=s737 lab=0}
N 10040 1400 10040 1420 {lab=0}
C {devices/gnd.sym} 10040 1420 0 0 {name=s738 lab=0}
N 10040 1370 10070 1370 {lab=0}
C {devices/gnd.sym} 10070 1370 0 0 {name=s739 lab=0}
N 59600 1400 59600 1420 {lab=0}
C {devices/gnd.sym} 59600 1420 0 0 {name=s740 lab=0}
N 59600 1370 59630 1370 {lab=0}
C {devices/gnd.sym} 59630 1370 0 0 {name=s741 lab=0}
N 59600 1220 59630 1220 {lab=0}
C {devices/gnd.sym} 59630 1220 0 0 {name=s742 lab=0}
N 59800 1070 59830 1070 {lab=0}
C {devices/gnd.sym} 59830 1070 0 0 {name=s743 lab=0}
N 59800 1220 59830 1220 {lab=0}
C {devices/gnd.sym} 59830 1220 0 0 {name=s744 lab=0}
N 59800 1400 59800 1420 {lab=0}
C {devices/gnd.sym} 59800 1420 0 0 {name=s745 lab=0}
N 59800 1370 59830 1370 {lab=0}
C {devices/gnd.sym} 59830 1370 0 0 {name=s746 lab=0}
N 60360 1400 60360 1420 {lab=0}
C {devices/gnd.sym} 60360 1420 0 0 {name=s747 lab=0}
N 60360 1370 60390 1370 {lab=0}
C {devices/gnd.sym} 60390 1370 0 0 {name=s748 lab=0}
N 60360 1220 60390 1220 {lab=0}
C {devices/gnd.sym} 60390 1220 0 0 {name=s749 lab=0}
N 60560 1220 60590 1220 {lab=0}
C {devices/gnd.sym} 60590 1220 0 0 {name=s750 lab=0}
N 60560 1400 60560 1420 {lab=0}
C {devices/gnd.sym} 60560 1420 0 0 {name=s751 lab=0}
N 60560 1370 60590 1370 {lab=0}
C {devices/gnd.sym} 60590 1370 0 0 {name=s752 lab=0}
N 30440 1400 30440 1420 {lab=0}
C {devices/gnd.sym} 30440 1420 0 0 {name=s753 lab=0}
N 30440 1370 30470 1370 {lab=0}
C {devices/gnd.sym} 30470 1370 0 0 {name=s754 lab=0}
N 30440 1220 30470 1220 {lab=0}
C {devices/gnd.sym} 30470 1220 0 0 {name=s755 lab=0}
N 31000 1400 31000 1420 {lab=0}
C {devices/gnd.sym} 31000 1420 0 0 {name=s756 lab=0}
N 31000 1370 31030 1370 {lab=0}
C {devices/gnd.sym} 31030 1370 0 0 {name=s757 lab=0}
N 6080 30 6080 10 {lab=VDD}
C {devices/vdd.sym} 6080 10 0 0 {name=s758 lab=VDD}
N 6080 60 6110 60 {lab=VDD}
C {devices/vdd.sym} 6110 60 0 0 {name=s759 lab=VDD}
N 10040 30 10040 10 {lab=VDD}
C {devices/vdd.sym} 10040 10 0 0 {name=s760 lab=VDD}
N 10040 60 10070 60 {lab=VDD}
C {devices/vdd.sym} 10070 60 0 0 {name=s761 lab=VDD}
N 59600 30 59600 10 {lab=VDD}
C {devices/vdd.sym} 59600 10 0 0 {name=s762 lab=VDD}
N 59600 60 59630 60 {lab=VDD}
C {devices/vdd.sym} 59630 60 0 0 {name=s763 lab=VDD}
N 59600 210 59630 210 {lab=VDD}
C {devices/vdd.sym} 59630 210 0 0 {name=s764 lab=VDD}
N 60000 210 60030 210 {lab=VDD}
C {devices/vdd.sym} 60030 210 0 0 {name=s765 lab=VDD}
N 59800 30 59800 10 {lab=VDD}
C {devices/vdd.sym} 59800 10 0 0 {name=s766 lab=VDD}
N 59800 60 59830 60 {lab=VDD}
C {devices/vdd.sym} 59830 60 0 0 {name=s767 lab=VDD}
N 60000 30 60000 10 {lab=VDD}
C {devices/vdd.sym} 60000 10 0 0 {name=s768 lab=VDD}
N 60000 60 60030 60 {lab=VDD}
C {devices/vdd.sym} 60030 60 0 0 {name=s769 lab=VDD}
N 60360 30 60360 10 {lab=VDD}
C {devices/vdd.sym} 60360 10 0 0 {name=s770 lab=VDD}
N 60360 60 60390 60 {lab=VDD}
C {devices/vdd.sym} 60390 60 0 0 {name=s771 lab=VDD}
N 60360 210 60390 210 {lab=VDD}
C {devices/vdd.sym} 60390 210 0 0 {name=s772 lab=VDD}
N 60560 210 60590 210 {lab=VDD}
C {devices/vdd.sym} 60590 210 0 0 {name=s773 lab=VDD}
N 60560 30 60560 10 {lab=VDD}
C {devices/vdd.sym} 60560 10 0 0 {name=s774 lab=VDD}
N 60560 60 60590 60 {lab=VDD}
C {devices/vdd.sym} 60590 60 0 0 {name=s775 lab=VDD}
N 30440 30 30440 10 {lab=VDD}
C {devices/vdd.sym} 30440 10 0 0 {name=s776 lab=VDD}
N 30440 60 30470 60 {lab=VDD}
C {devices/vdd.sym} 30470 60 0 0 {name=s777 lab=VDD}
N 30640 30 30640 10 {lab=VDD}
C {devices/vdd.sym} 30640 10 0 0 {name=s778 lab=VDD}
N 30640 60 30670 60 {lab=VDD}
C {devices/vdd.sym} 30670 60 0 0 {name=s779 lab=VDD}
N 31000 30 31000 10 {lab=VDD}
C {devices/vdd.sym} 31000 10 0 0 {name=s780 lab=VDD}
N 31000 60 31030 60 {lab=VDD}
C {devices/vdd.sym} 31030 60 0 0 {name=s781 lab=VDD}
N 6440 1400 6440 1420 {lab=0}
C {devices/gnd.sym} 6440 1420 0 0 {name=s782 lab=0}
N 6440 1370 6470 1370 {lab=0}
C {devices/gnd.sym} 6470 1370 0 0 {name=s783 lab=0}
N 10400 1400 10400 1420 {lab=0}
C {devices/gnd.sym} 10400 1420 0 0 {name=s784 lab=0}
N 10400 1370 10430 1370 {lab=0}
C {devices/gnd.sym} 10430 1370 0 0 {name=s785 lab=0}
N 60920 1400 60920 1420 {lab=0}
C {devices/gnd.sym} 60920 1420 0 0 {name=s786 lab=0}
N 60920 1370 60950 1370 {lab=0}
C {devices/gnd.sym} 60950 1370 0 0 {name=s787 lab=0}
N 60920 1220 60950 1220 {lab=0}
C {devices/gnd.sym} 60950 1220 0 0 {name=s788 lab=0}
N 61120 1070 61150 1070 {lab=0}
C {devices/gnd.sym} 61150 1070 0 0 {name=s789 lab=0}
N 61120 1220 61150 1220 {lab=0}
C {devices/gnd.sym} 61150 1220 0 0 {name=s790 lab=0}
N 61120 1400 61120 1420 {lab=0}
C {devices/gnd.sym} 61120 1420 0 0 {name=s791 lab=0}
N 61120 1370 61150 1370 {lab=0}
C {devices/gnd.sym} 61150 1370 0 0 {name=s792 lab=0}
N 61680 1400 61680 1420 {lab=0}
C {devices/gnd.sym} 61680 1420 0 0 {name=s793 lab=0}
N 61680 1370 61710 1370 {lab=0}
C {devices/gnd.sym} 61710 1370 0 0 {name=s794 lab=0}
N 61680 1220 61710 1220 {lab=0}
C {devices/gnd.sym} 61710 1220 0 0 {name=s795 lab=0}
N 61880 1220 61910 1220 {lab=0}
C {devices/gnd.sym} 61910 1220 0 0 {name=s796 lab=0}
N 61880 1400 61880 1420 {lab=0}
C {devices/gnd.sym} 61880 1420 0 0 {name=s797 lab=0}
N 61880 1370 61910 1370 {lab=0}
C {devices/gnd.sym} 61910 1370 0 0 {name=s798 lab=0}
N 31360 1400 31360 1420 {lab=0}
C {devices/gnd.sym} 31360 1420 0 0 {name=s799 lab=0}
N 31360 1370 31390 1370 {lab=0}
C {devices/gnd.sym} 31390 1370 0 0 {name=s800 lab=0}
N 31360 1220 31390 1220 {lab=0}
C {devices/gnd.sym} 31390 1220 0 0 {name=s801 lab=0}
N 31920 1400 31920 1420 {lab=0}
C {devices/gnd.sym} 31920 1420 0 0 {name=s802 lab=0}
N 31920 1370 31950 1370 {lab=0}
C {devices/gnd.sym} 31950 1370 0 0 {name=s803 lab=0}
N 6440 30 6440 10 {lab=VDD}
C {devices/vdd.sym} 6440 10 0 0 {name=s804 lab=VDD}
N 6440 60 6470 60 {lab=VDD}
C {devices/vdd.sym} 6470 60 0 0 {name=s805 lab=VDD}
N 10400 30 10400 10 {lab=VDD}
C {devices/vdd.sym} 10400 10 0 0 {name=s806 lab=VDD}
N 10400 60 10430 60 {lab=VDD}
C {devices/vdd.sym} 10430 60 0 0 {name=s807 lab=VDD}
N 60920 30 60920 10 {lab=VDD}
C {devices/vdd.sym} 60920 10 0 0 {name=s808 lab=VDD}
N 60920 60 60950 60 {lab=VDD}
C {devices/vdd.sym} 60950 60 0 0 {name=s809 lab=VDD}
N 60920 210 60950 210 {lab=VDD}
C {devices/vdd.sym} 60950 210 0 0 {name=s810 lab=VDD}
N 61320 210 61350 210 {lab=VDD}
C {devices/vdd.sym} 61350 210 0 0 {name=s811 lab=VDD}
N 61120 30 61120 10 {lab=VDD}
C {devices/vdd.sym} 61120 10 0 0 {name=s812 lab=VDD}
N 61120 60 61150 60 {lab=VDD}
C {devices/vdd.sym} 61150 60 0 0 {name=s813 lab=VDD}
N 61320 30 61320 10 {lab=VDD}
C {devices/vdd.sym} 61320 10 0 0 {name=s814 lab=VDD}
N 61320 60 61350 60 {lab=VDD}
C {devices/vdd.sym} 61350 60 0 0 {name=s815 lab=VDD}
N 61680 30 61680 10 {lab=VDD}
C {devices/vdd.sym} 61680 10 0 0 {name=s816 lab=VDD}
N 61680 60 61710 60 {lab=VDD}
C {devices/vdd.sym} 61710 60 0 0 {name=s817 lab=VDD}
N 61680 210 61710 210 {lab=VDD}
C {devices/vdd.sym} 61710 210 0 0 {name=s818 lab=VDD}
N 61880 210 61910 210 {lab=VDD}
C {devices/vdd.sym} 61910 210 0 0 {name=s819 lab=VDD}
N 61880 30 61880 10 {lab=VDD}
C {devices/vdd.sym} 61880 10 0 0 {name=s820 lab=VDD}
N 61880 60 61910 60 {lab=VDD}
C {devices/vdd.sym} 61910 60 0 0 {name=s821 lab=VDD}
N 31360 30 31360 10 {lab=VDD}
C {devices/vdd.sym} 31360 10 0 0 {name=s822 lab=VDD}
N 31360 60 31390 60 {lab=VDD}
C {devices/vdd.sym} 31390 60 0 0 {name=s823 lab=VDD}
N 31560 30 31560 10 {lab=VDD}
C {devices/vdd.sym} 31560 10 0 0 {name=s824 lab=VDD}
N 31560 60 31590 60 {lab=VDD}
C {devices/vdd.sym} 31590 60 0 0 {name=s825 lab=VDD}
N 31920 30 31920 10 {lab=VDD}
C {devices/vdd.sym} 31920 10 0 0 {name=s826 lab=VDD}
N 31920 60 31950 60 {lab=VDD}
C {devices/vdd.sym} 31950 60 0 0 {name=s827 lab=VDD}
N 6800 1400 6800 1420 {lab=0}
C {devices/gnd.sym} 6800 1420 0 0 {name=s828 lab=0}
N 6800 1370 6830 1370 {lab=0}
C {devices/gnd.sym} 6830 1370 0 0 {name=s829 lab=0}
N 10760 1400 10760 1420 {lab=0}
C {devices/gnd.sym} 10760 1420 0 0 {name=s830 lab=0}
N 10760 1370 10790 1370 {lab=0}
C {devices/gnd.sym} 10790 1370 0 0 {name=s831 lab=0}
N 62240 1400 62240 1420 {lab=0}
C {devices/gnd.sym} 62240 1420 0 0 {name=s832 lab=0}
N 62240 1370 62270 1370 {lab=0}
C {devices/gnd.sym} 62270 1370 0 0 {name=s833 lab=0}
N 62240 1220 62270 1220 {lab=0}
C {devices/gnd.sym} 62270 1220 0 0 {name=s834 lab=0}
N 62440 1070 62470 1070 {lab=0}
C {devices/gnd.sym} 62470 1070 0 0 {name=s835 lab=0}
N 62440 1220 62470 1220 {lab=0}
C {devices/gnd.sym} 62470 1220 0 0 {name=s836 lab=0}
N 62440 1400 62440 1420 {lab=0}
C {devices/gnd.sym} 62440 1420 0 0 {name=s837 lab=0}
N 62440 1370 62470 1370 {lab=0}
C {devices/gnd.sym} 62470 1370 0 0 {name=s838 lab=0}
N 63000 1400 63000 1420 {lab=0}
C {devices/gnd.sym} 63000 1420 0 0 {name=s839 lab=0}
N 63000 1370 63030 1370 {lab=0}
C {devices/gnd.sym} 63030 1370 0 0 {name=s840 lab=0}
N 63000 1220 63030 1220 {lab=0}
C {devices/gnd.sym} 63030 1220 0 0 {name=s841 lab=0}
N 63200 1220 63230 1220 {lab=0}
C {devices/gnd.sym} 63230 1220 0 0 {name=s842 lab=0}
N 63200 1400 63200 1420 {lab=0}
C {devices/gnd.sym} 63200 1420 0 0 {name=s843 lab=0}
N 63200 1370 63230 1370 {lab=0}
C {devices/gnd.sym} 63230 1370 0 0 {name=s844 lab=0}
N 32640 1400 32640 1420 {lab=0}
C {devices/gnd.sym} 32640 1420 0 0 {name=s845 lab=0}
N 32640 1370 32670 1370 {lab=0}
C {devices/gnd.sym} 32670 1370 0 0 {name=s846 lab=0}
N 32640 1220 32670 1220 {lab=0}
C {devices/gnd.sym} 32670 1220 0 0 {name=s847 lab=0}
N 33200 1400 33200 1420 {lab=0}
C {devices/gnd.sym} 33200 1420 0 0 {name=s848 lab=0}
N 33200 1370 33230 1370 {lab=0}
C {devices/gnd.sym} 33230 1370 0 0 {name=s849 lab=0}
N 6800 30 6800 10 {lab=VDD}
C {devices/vdd.sym} 6800 10 0 0 {name=s850 lab=VDD}
N 6800 60 6830 60 {lab=VDD}
C {devices/vdd.sym} 6830 60 0 0 {name=s851 lab=VDD}
N 10760 30 10760 10 {lab=VDD}
C {devices/vdd.sym} 10760 10 0 0 {name=s852 lab=VDD}
N 10760 60 10790 60 {lab=VDD}
C {devices/vdd.sym} 10790 60 0 0 {name=s853 lab=VDD}
N 62240 30 62240 10 {lab=VDD}
C {devices/vdd.sym} 62240 10 0 0 {name=s854 lab=VDD}
N 62240 60 62270 60 {lab=VDD}
C {devices/vdd.sym} 62270 60 0 0 {name=s855 lab=VDD}
N 62240 210 62270 210 {lab=VDD}
C {devices/vdd.sym} 62270 210 0 0 {name=s856 lab=VDD}
N 62640 210 62670 210 {lab=VDD}
C {devices/vdd.sym} 62670 210 0 0 {name=s857 lab=VDD}
N 62440 30 62440 10 {lab=VDD}
C {devices/vdd.sym} 62440 10 0 0 {name=s858 lab=VDD}
N 62440 60 62470 60 {lab=VDD}
C {devices/vdd.sym} 62470 60 0 0 {name=s859 lab=VDD}
N 62640 30 62640 10 {lab=VDD}
C {devices/vdd.sym} 62640 10 0 0 {name=s860 lab=VDD}
N 62640 60 62670 60 {lab=VDD}
C {devices/vdd.sym} 62670 60 0 0 {name=s861 lab=VDD}
N 63000 30 63000 10 {lab=VDD}
C {devices/vdd.sym} 63000 10 0 0 {name=s862 lab=VDD}
N 63000 60 63030 60 {lab=VDD}
C {devices/vdd.sym} 63030 60 0 0 {name=s863 lab=VDD}
N 63000 210 63030 210 {lab=VDD}
C {devices/vdd.sym} 63030 210 0 0 {name=s864 lab=VDD}
N 63200 210 63230 210 {lab=VDD}
C {devices/vdd.sym} 63230 210 0 0 {name=s865 lab=VDD}
N 63200 30 63200 10 {lab=VDD}
C {devices/vdd.sym} 63200 10 0 0 {name=s866 lab=VDD}
N 63200 60 63230 60 {lab=VDD}
C {devices/vdd.sym} 63230 60 0 0 {name=s867 lab=VDD}
N 32640 30 32640 10 {lab=VDD}
C {devices/vdd.sym} 32640 10 0 0 {name=s868 lab=VDD}
N 32640 60 32670 60 {lab=VDD}
C {devices/vdd.sym} 32670 60 0 0 {name=s869 lab=VDD}
N 32840 30 32840 10 {lab=VDD}
C {devices/vdd.sym} 32840 10 0 0 {name=s870 lab=VDD}
N 32840 60 32870 60 {lab=VDD}
C {devices/vdd.sym} 32870 60 0 0 {name=s871 lab=VDD}
N 33200 30 33200 10 {lab=VDD}
C {devices/vdd.sym} 33200 10 0 0 {name=s872 lab=VDD}
N 33200 60 33230 60 {lab=VDD}
C {devices/vdd.sym} 33230 60 0 0 {name=s873 lab=VDD}
N 7160 1400 7160 1420 {lab=0}
C {devices/gnd.sym} 7160 1420 0 0 {name=s874 lab=0}
N 7160 1370 7190 1370 {lab=0}
C {devices/gnd.sym} 7190 1370 0 0 {name=s875 lab=0}
N 11120 1400 11120 1420 {lab=0}
C {devices/gnd.sym} 11120 1420 0 0 {name=s876 lab=0}
N 11120 1370 11150 1370 {lab=0}
C {devices/gnd.sym} 11150 1370 0 0 {name=s877 lab=0}
N 63560 1400 63560 1420 {lab=0}
C {devices/gnd.sym} 63560 1420 0 0 {name=s878 lab=0}
N 63560 1370 63590 1370 {lab=0}
C {devices/gnd.sym} 63590 1370 0 0 {name=s879 lab=0}
N 63560 1220 63590 1220 {lab=0}
C {devices/gnd.sym} 63590 1220 0 0 {name=s880 lab=0}
N 63760 1070 63790 1070 {lab=0}
C {devices/gnd.sym} 63790 1070 0 0 {name=s881 lab=0}
N 63760 1220 63790 1220 {lab=0}
C {devices/gnd.sym} 63790 1220 0 0 {name=s882 lab=0}
N 63760 1400 63760 1420 {lab=0}
C {devices/gnd.sym} 63760 1420 0 0 {name=s883 lab=0}
N 63760 1370 63790 1370 {lab=0}
C {devices/gnd.sym} 63790 1370 0 0 {name=s884 lab=0}
N 64320 1400 64320 1420 {lab=0}
C {devices/gnd.sym} 64320 1420 0 0 {name=s885 lab=0}
N 64320 1370 64350 1370 {lab=0}
C {devices/gnd.sym} 64350 1370 0 0 {name=s886 lab=0}
N 64320 1220 64350 1220 {lab=0}
C {devices/gnd.sym} 64350 1220 0 0 {name=s887 lab=0}
N 64520 1220 64550 1220 {lab=0}
C {devices/gnd.sym} 64550 1220 0 0 {name=s888 lab=0}
N 64520 1400 64520 1420 {lab=0}
C {devices/gnd.sym} 64520 1420 0 0 {name=s889 lab=0}
N 64520 1370 64550 1370 {lab=0}
C {devices/gnd.sym} 64550 1370 0 0 {name=s890 lab=0}
N 34480 1400 34480 1420 {lab=0}
C {devices/gnd.sym} 34480 1420 0 0 {name=s891 lab=0}
N 34480 1370 34510 1370 {lab=0}
C {devices/gnd.sym} 34510 1370 0 0 {name=s892 lab=0}
N 34480 1220 34510 1220 {lab=0}
C {devices/gnd.sym} 34510 1220 0 0 {name=s893 lab=0}
N 35040 1400 35040 1420 {lab=0}
C {devices/gnd.sym} 35040 1420 0 0 {name=s894 lab=0}
N 35040 1370 35070 1370 {lab=0}
C {devices/gnd.sym} 35070 1370 0 0 {name=s895 lab=0}
N 7160 30 7160 10 {lab=VDD}
C {devices/vdd.sym} 7160 10 0 0 {name=s896 lab=VDD}
N 7160 60 7190 60 {lab=VDD}
C {devices/vdd.sym} 7190 60 0 0 {name=s897 lab=VDD}
N 11120 30 11120 10 {lab=VDD}
C {devices/vdd.sym} 11120 10 0 0 {name=s898 lab=VDD}
N 11120 60 11150 60 {lab=VDD}
C {devices/vdd.sym} 11150 60 0 0 {name=s899 lab=VDD}
N 63560 30 63560 10 {lab=VDD}
C {devices/vdd.sym} 63560 10 0 0 {name=s900 lab=VDD}
N 63560 60 63590 60 {lab=VDD}
C {devices/vdd.sym} 63590 60 0 0 {name=s901 lab=VDD}
N 63560 210 63590 210 {lab=VDD}
C {devices/vdd.sym} 63590 210 0 0 {name=s902 lab=VDD}
N 63960 210 63990 210 {lab=VDD}
C {devices/vdd.sym} 63990 210 0 0 {name=s903 lab=VDD}
N 63760 30 63760 10 {lab=VDD}
C {devices/vdd.sym} 63760 10 0 0 {name=s904 lab=VDD}
N 63760 60 63790 60 {lab=VDD}
C {devices/vdd.sym} 63790 60 0 0 {name=s905 lab=VDD}
N 63960 30 63960 10 {lab=VDD}
C {devices/vdd.sym} 63960 10 0 0 {name=s906 lab=VDD}
N 63960 60 63990 60 {lab=VDD}
C {devices/vdd.sym} 63990 60 0 0 {name=s907 lab=VDD}
N 64320 30 64320 10 {lab=VDD}
C {devices/vdd.sym} 64320 10 0 0 {name=s908 lab=VDD}
N 64320 60 64350 60 {lab=VDD}
C {devices/vdd.sym} 64350 60 0 0 {name=s909 lab=VDD}
N 64320 210 64350 210 {lab=VDD}
C {devices/vdd.sym} 64350 210 0 0 {name=s910 lab=VDD}
N 64520 210 64550 210 {lab=VDD}
C {devices/vdd.sym} 64550 210 0 0 {name=s911 lab=VDD}
N 64520 30 64520 10 {lab=VDD}
C {devices/vdd.sym} 64520 10 0 0 {name=s912 lab=VDD}
N 64520 60 64550 60 {lab=VDD}
C {devices/vdd.sym} 64550 60 0 0 {name=s913 lab=VDD}
N 34480 30 34480 10 {lab=VDD}
C {devices/vdd.sym} 34480 10 0 0 {name=s914 lab=VDD}
N 34480 60 34510 60 {lab=VDD}
C {devices/vdd.sym} 34510 60 0 0 {name=s915 lab=VDD}
N 34680 30 34680 10 {lab=VDD}
C {devices/vdd.sym} 34680 10 0 0 {name=s916 lab=VDD}
N 34680 60 34710 60 {lab=VDD}
C {devices/vdd.sym} 34710 60 0 0 {name=s917 lab=VDD}
N 35040 30 35040 10 {lab=VDD}
C {devices/vdd.sym} 35040 10 0 0 {name=s918 lab=VDD}
N 35040 60 35070 60 {lab=VDD}
C {devices/vdd.sym} 35070 60 0 0 {name=s919 lab=VDD}
N 11480 1400 11480 1420 {lab=0}
C {devices/gnd.sym} 11480 1420 0 0 {name=s920 lab=0}
N 11480 1370 11510 1370 {lab=0}
C {devices/gnd.sym} 11510 1370 0 0 {name=s921 lab=0}
N 11840 30 11840 10 {lab=VDD}
C {devices/vdd.sym} 11840 10 0 0 {name=s922 lab=VDD}
N 11840 60 11870 60 {lab=VDD}
C {devices/vdd.sym} 11870 60 0 0 {name=s923 lab=VDD}
N 17600 1370 17590 1370 {lab=rst_n}
N 17590 1370 17590 1330 {lab=rst_n}
N 17590 1330 12550 1330 {lab=rst_n}
N 17590 1330 17680 1330 {lab=rst_n}
N 17680 1330 17680 1370 {lab=rst_n}
N 17680 1370 17790 1370 {lab=rst_n}
N 17790 1370 17790 100 {lab=rst_n}
N 17790 1370 18150 1370 {lab=rst_n}
N 18150 1370 18160 1370 {lab=rst_n}
N 18150 1370 18150 1330 {lab=rst_n}
N 17790 100 17880 100 {lab=rst_n}
N 17790 100 17790 60 {lab=rst_n}
N 17790 60 17800 60 {lab=rst_n}
N 17880 100 17880 60 {lab=rst_n}
N 17880 60 18160 60 {lab=rst_n}
N 18150 1330 19720 1330 {lab=rst_n}
N 19720 1330 19720 1370 {lab=rst_n}
N 19720 1370 19830 1370 {lab=rst_n}
N 19830 1370 19840 1370 {lab=rst_n}
N 19830 1370 19830 1330 {lab=rst_n}
N 19830 1330 19920 1330 {lab=rst_n}
N 19920 1330 19920 1370 {lab=rst_n}
N 19920 1370 20030 1370 {lab=rst_n}
N 20030 1370 20390 1370 {lab=rst_n}
N 20030 1370 20030 100 {lab=rst_n}
N 20390 1370 20390 1330 {lab=rst_n}
N 20390 1370 20400 1370 {lab=rst_n}
N 20030 100 20030 60 {lab=rst_n}
N 20030 100 20120 100 {lab=rst_n}
N 20030 60 20040 60 {lab=rst_n}
N 20120 100 20120 60 {lab=rst_n}
N 20120 60 20400 60 {lab=rst_n}
N 20390 1330 21600 1330 {lab=rst_n}
N 21600 1330 21600 1370 {lab=rst_n}
N 21600 1370 21870 1370 {lab=rst_n}
N 21870 1370 21880 1370 {lab=rst_n}
N 21870 1370 21870 1330 {lab=rst_n}
N 12550 1330 12350 1330 {lab=rst_n}
N 12550 1330 12550 610 {lab=rst_n}
N 12350 1330 12350 1370 {lab=rst_n}
N 12350 1370 12360 1370 {lab=rst_n}
N 21870 1330 23440 1330 {lab=rst_n}
N 21870 1330 21870 60 {lab=rst_n}
N 21870 60 21880 60 {lab=rst_n}
N 23440 1330 23440 1370 {lab=rst_n}
N 23440 1370 23550 1370 {lab=rst_n}
N 23550 1370 23560 1370 {lab=rst_n}
N 23550 1370 23550 1330 {lab=rst_n}
N 12550 610 -60 610 {lab=rst_n}
N 12550 610 12550 60 {lab=rst_n}
N 12550 60 12560 60 {lab=rst_n}
N 23550 1330 23640 1330 {lab=rst_n}
N 23640 1330 23640 1370 {lab=rst_n}
N 23640 1370 23750 1370 {lab=rst_n}
N 23750 1370 24110 1370 {lab=rst_n}
N 23750 1370 23750 100 {lab=rst_n}
N 24110 1370 24110 1330 {lab=rst_n}
N 24110 1370 24120 1370 {lab=rst_n}
N 23750 100 23750 60 {lab=rst_n}
N 23750 100 23840 100 {lab=rst_n}
N 23750 60 23760 60 {lab=rst_n}
N 23840 100 23840 60 {lab=rst_n}
N 23840 60 24120 60 {lab=rst_n}
N 24110 1330 25680 1330 {lab=rst_n}
N 25680 1330 25680 1370 {lab=rst_n}
N 25680 1370 25790 1370 {lab=rst_n}
N 25790 1370 25790 1330 {lab=rst_n}
N 25790 1370 25800 1370 {lab=rst_n}
N 25790 1330 25880 1330 {lab=rst_n}
N 25880 1330 25880 1370 {lab=rst_n}
N 25880 1370 25990 1370 {lab=rst_n}
N 25990 1370 25990 100 {lab=rst_n}
N 25990 1370 26350 1370 {lab=rst_n}
N 26350 1370 26360 1370 {lab=rst_n}
N 26350 1370 26350 1330 {lab=rst_n}
N 25990 100 26080 100 {lab=rst_n}
N 25990 100 25990 60 {lab=rst_n}
N 25990 60 26000 60 {lab=rst_n}
N 26080 100 26080 60 {lab=rst_n}
N 26080 60 26360 60 {lab=rst_n}
N 26350 1330 27920 1330 {lab=rst_n}
N 27920 1330 27920 1370 {lab=rst_n}
N 27920 1370 28190 1370 {lab=rst_n}
N 28190 1370 28200 1370 {lab=rst_n}
N 28190 1370 28190 1330 {lab=rst_n}
N 28190 1330 29200 1330 {lab=rst_n}
N 28190 1330 28190 60 {lab=rst_n}
N 29200 1330 29200 1370 {lab=rst_n}
N 29200 1370 29470 1370 {lab=rst_n}
N 29470 1370 29480 1370 {lab=rst_n}
N 29470 1370 29470 1330 {lab=rst_n}
N 28190 60 28200 60 {lab=rst_n}
N 29470 1330 30120 1330 {lab=rst_n}
N 29470 1330 29470 100 {lab=rst_n}
N 30120 1330 30120 1370 {lab=rst_n}
N 30120 1370 30390 1370 {lab=rst_n}
N 30390 1370 30400 1370 {lab=rst_n}
N 30390 1370 30390 1330 {lab=rst_n}
N 29470 100 30120 100 {lab=rst_n}
N 29470 100 29470 60 {lab=rst_n}
N 29470 60 29480 60 {lab=rst_n}
N 30390 1330 31040 1330 {lab=rst_n}
N 31040 1330 31040 1370 {lab=rst_n}
N 31040 1370 31310 1370 {lab=rst_n}
N 31310 1370 31310 1330 {lab=rst_n}
N 31310 1370 31320 1370 {lab=rst_n}
N 30120 100 30120 60 {lab=rst_n}
N 30120 60 30390 60 {lab=rst_n}
N 30390 60 30390 100 {lab=rst_n}
N 30390 60 30400 60 {lab=rst_n}
N 31310 1330 32320 1330 {lab=rst_n}
N 32320 1330 32320 1370 {lab=rst_n}
N 32320 1370 32590 1370 {lab=rst_n}
N 32590 1370 32600 1370 {lab=rst_n}
N 32590 1370 32590 1330 {lab=rst_n}
N 30390 100 31040 100 {lab=rst_n}
N 31040 100 31040 60 {lab=rst_n}
N 31040 60 31320 60 {lab=rst_n}
N 32590 1330 34160 1330 {lab=rst_n}
N 32590 1330 32590 60 {lab=rst_n}
N 32590 60 32600 60 {lab=rst_n}
N 34160 1330 34160 1370 {lab=rst_n}
N 34160 1370 34430 1370 {lab=rst_n}
N 34430 1370 34430 1330 {lab=rst_n}
N 34430 1370 34440 1370 {lab=rst_n}
N 34430 1330 57000 1330 {lab=rst_n}
N 34430 1330 34430 60 {lab=rst_n}
N 34430 60 34440 60 {lab=rst_n}
N 57000 1330 57000 1370 {lab=rst_n}
N 57000 1370 57110 1370 {lab=rst_n}
N 57110 1370 57120 1370 {lab=rst_n}
N 57110 1370 57110 1330 {lab=rst_n}
N 57110 1330 57310 1330 {lab=rst_n}
N 57310 1330 57310 60 {lab=rst_n}
N 57310 1330 58320 1330 {lab=rst_n}
N 58320 1330 58320 1370 {lab=rst_n}
N 58320 1370 58430 1370 {lab=rst_n}
N 58430 1370 58430 1330 {lab=rst_n}
N 58430 1370 58440 1370 {lab=rst_n}
N 57310 60 57320 60 {lab=rst_n}
N 58430 1330 58630 1330 {lab=rst_n}
N 58630 1330 58630 60 {lab=rst_n}
N 58630 1330 59640 1330 {lab=rst_n}
N 59640 1330 59640 1370 {lab=rst_n}
N 59640 1370 59750 1370 {lab=rst_n}
N 59750 1370 59760 1370 {lab=rst_n}
N 59750 1370 59750 1330 {lab=rst_n}
N 58630 60 58640 60 {lab=rst_n}
N 59750 1330 59950 1330 {lab=rst_n}
N 59950 1330 60960 1330 {lab=rst_n}
N 59950 1330 59950 60 {lab=rst_n}
N 60960 1330 60960 1370 {lab=rst_n}
N 60960 1370 61070 1370 {lab=rst_n}
N 61070 1370 61080 1370 {lab=rst_n}
N 61070 1370 61070 1330 {lab=rst_n}
N 59950 60 59960 60 {lab=rst_n}
N 61070 1330 61270 1330 {lab=rst_n}
N 61270 1330 61270 60 {lab=rst_n}
N 61270 1330 62280 1330 {lab=rst_n}
N 62280 1330 62280 1370 {lab=rst_n}
N 62280 1370 62390 1370 {lab=rst_n}
N 62390 1370 62390 1330 {lab=rst_n}
N 62390 1370 62400 1370 {lab=rst_n}
N 61270 60 61280 60 {lab=rst_n}
N 62390 1330 62590 1330 {lab=rst_n}
N 62590 1330 63600 1330 {lab=rst_n}
N 62590 1330 62590 100 {lab=rst_n}
N 63600 1330 63600 1370 {lab=rst_n}
N 63600 1370 63720 1370 {lab=rst_n}
N 62590 100 63800 100 {lab=rst_n}
N 62590 100 62590 60 {lab=rst_n}
N 62590 60 62600 60 {lab=rst_n}
N 63800 100 63800 60 {lab=rst_n}
N 63800 60 63920 60 {lab=rst_n}
N 3520 1370 3510 1370 {lab=clk}
N 3510 1370 3510 1330 {lab=clk}
N 3510 1330 3600 1330 {lab=clk}
N 3510 1330 3510 470 {lab=clk}
N 3600 1330 3600 1370 {lab=clk}
N 3600 1370 3870 1370 {lab=clk}
N 3870 1370 3880 1370 {lab=clk}
N 3870 1370 3870 1330 {lab=clk}
N 3870 1330 3960 1330 {lab=clk}
N 3960 1330 3960 1370 {lab=clk}
N 3960 1370 4230 1370 {lab=clk}
N 4230 1370 4240 1370 {lab=clk}
N 4230 1370 4230 1330 {lab=clk}
N 4230 1330 4320 1330 {lab=clk}
N 4320 1330 4320 1370 {lab=clk}
N 4320 1370 4590 1370 {lab=clk}
N 4590 1370 4590 1330 {lab=clk}
N 4590 1370 4600 1370 {lab=clk}
N 3510 470 -60 470 {lab=clk}
N 3510 470 3510 100 {lab=clk}
N 3510 100 3600 100 {lab=clk}
N 3510 100 3510 60 {lab=clk}
N 3510 60 3520 60 {lab=clk}
N 4590 1330 4680 1330 {lab=clk}
N 4680 1330 4680 1370 {lab=clk}
N 4680 1370 4950 1370 {lab=clk}
N 4950 1370 4950 1330 {lab=clk}
N 4950 1370 4960 1370 {lab=clk}
N 3600 100 3600 60 {lab=clk}
N 3600 60 3870 60 {lab=clk}
N 3870 60 3870 100 {lab=clk}
N 3870 60 3880 60 {lab=clk}
N 4950 1330 5040 1330 {lab=clk}
N 5040 1330 5040 1370 {lab=clk}
N 5040 1370 5310 1370 {lab=clk}
N 5310 1370 5320 1370 {lab=clk}
N 5310 1370 5310 1330 {lab=clk}
N 3870 100 3960 100 {lab=clk}
N 3960 100 3960 60 {lab=clk}
N 3960 60 4230 60 {lab=clk}
N 4230 60 4240 60 {lab=clk}
N 4230 60 4230 100 {lab=clk}
N 5310 1330 5400 1330 {lab=clk}
N 5400 1330 5400 1370 {lab=clk}
N 5400 1370 5670 1370 {lab=clk}
N 5670 1370 5680 1370 {lab=clk}
N 5670 1370 5670 1330 {lab=clk}
N 4230 100 4320 100 {lab=clk}
N 4320 100 4320 60 {lab=clk}
N 4320 60 4590 60 {lab=clk}
N 4590 60 4590 100 {lab=clk}
N 4590 60 4600 60 {lab=clk}
N 5670 1330 5760 1330 {lab=clk}
N 5760 1330 5760 1370 {lab=clk}
N 5760 1370 6030 1370 {lab=clk}
N 6030 1370 6040 1370 {lab=clk}
N 6030 1370 6030 1330 {lab=clk}
N 4590 100 4680 100 {lab=clk}
N 4680 100 4680 60 {lab=clk}
N 4680 60 4950 60 {lab=clk}
N 4950 60 4950 100 {lab=clk}
N 4950 60 4960 60 {lab=clk}
N 6030 1330 6120 1330 {lab=clk}
N 6120 1330 6120 1370 {lab=clk}
N 6120 1370 6390 1370 {lab=clk}
N 6390 1370 6400 1370 {lab=clk}
N 6390 1370 6390 1330 {lab=clk}
N 4950 100 5040 100 {lab=clk}
N 5040 100 5040 60 {lab=clk}
N 5040 60 5310 60 {lab=clk}
N 5310 60 5310 100 {lab=clk}
N 5310 60 5320 60 {lab=clk}
N 6390 1330 6480 1330 {lab=clk}
N 6480 1330 6480 1370 {lab=clk}
N 6480 1370 6750 1370 {lab=clk}
N 6750 1370 6760 1370 {lab=clk}
N 6750 1370 6750 1330 {lab=clk}
N 5310 100 5400 100 {lab=clk}
N 5400 100 5400 60 {lab=clk}
N 5400 60 5670 60 {lab=clk}
N 5670 60 5680 60 {lab=clk}
N 5670 60 5670 100 {lab=clk}
N 6750 1330 6840 1330 {lab=clk}
N 6840 1330 6840 1370 {lab=clk}
N 6840 1370 7120 1370 {lab=clk}
N 5670 100 5760 100 {lab=clk}
N 5760 100 5760 60 {lab=clk}
N 5760 60 6030 60 {lab=clk}
N 6030 60 6030 100 {lab=clk}
N 6030 60 6040 60 {lab=clk}
N 6030 100 6120 100 {lab=clk}
N 6120 100 6120 60 {lab=clk}
N 6120 60 6390 60 {lab=clk}
N 6390 60 6390 100 {lab=clk}
N 6390 60 6400 60 {lab=clk}
N -60 470 -60 490 {lab=clk}
N 6390 100 6480 100 {lab=clk}
N 6480 100 6480 60 {lab=clk}
N 6480 60 6750 60 {lab=clk}
N 6750 60 6750 100 {lab=clk}
N 6750 60 6760 60 {lab=clk}
N 6750 100 6840 100 {lab=clk}
N 6840 100 6840 60 {lab=clk}
N 6840 60 7120 60 {lab=clk}
N 32240 1370 32230 1370 {lab=state_0}
N 32230 1370 32230 1340 {lab=state_0}
N 32230 1340 31920 1340 {lab=state_0}
N 32230 1340 32230 1320 {lab=state_0}
N 32230 1320 32230 90 {lab=state_0}
N 32230 1320 35710 1320 {lab=state_0}
N 32230 90 31920 90 {lab=state_0}
N 32230 90 32230 60 {lab=state_0}
N 32230 60 32240 60 {lab=state_0}
N 35710 1320 36000 1320 {lab=state_0}
N 35710 1320 35710 360 {lab=state_0}
N 36000 1320 36000 1370 {lab=state_0}
N 36000 1370 36110 1370 {lab=state_0}
N 36110 1370 36110 1430 {lab=state_0}
N 36110 1370 36120 1370 {lab=state_0}
N 35710 360 35720 360 {lab=state_0}
N 36110 1430 38350 1430 {lab=state_0}
N 38350 1430 38640 1430 {lab=state_0}
N 38350 1430 38350 360 {lab=state_0}
N 38640 1430 38640 1370 {lab=state_0}
N 38640 1430 40990 1430 {lab=state_0}
N 38640 1370 38760 1370 {lab=state_0}
N 38350 360 38360 360 {lab=state_0}
N 40990 1430 41480 1430 {lab=state_0}
N 40990 1430 40990 510 {lab=state_0}
N 41480 1430 41480 1370 {lab=state_0}
N 41480 1430 51760 1430 {lab=state_0}
N 41480 1370 41600 1370 {lab=state_0}
N 40990 510 41000 510 {lab=state_0}
N 51760 1430 51760 1370 {lab=state_0}
N 51760 1370 52230 1370 {lab=state_0}
N 52230 1370 52240 1370 {lab=state_0}
N 52230 1370 52230 1320 {lab=state_0}
N 52230 1320 52320 1320 {lab=state_0}
N 52320 1320 52320 1110 {lab=state_0}
N 52320 1110 52880 1110 {lab=state_0}
N 52320 1110 52320 60 {lab=state_0}
N 52320 60 52440 60 {lab=state_0}
N 52880 1110 52880 1070 {lab=state_0}
N 52880 1070 54470 1070 {lab=state_0}
N 54470 1070 54470 1030 {lab=state_0}
N 54470 1070 54480 1070 {lab=state_0}
N 54470 1030 54760 1030 {lab=state_0}
N 54760 1030 54760 60 {lab=state_0}
N 54760 1030 54760 1110 {lab=state_0}
N 54760 60 54880 60 {lab=state_0}
N 54760 1110 64900 1110 {lab=state_0}
N 13880 1190 13920 1190 {lab=_102_}
N 13880 1190 13880 100 {lab=_102_}
N 13880 100 14080 100 {lab=_102_}
N 13880 100 13880 90 {lab=_102_}
N 14080 100 14080 90 {lab=_102_}
N 13920 1190 13920 1440 {lab=_102_}
N 13920 1440 39110 1440 {lab=_102_}
N 39110 1440 39110 360 {lab=_102_}
N 39110 1440 39400 1440 {lab=_102_}
N 39400 1440 39400 1370 {lab=_102_}
N 39400 1370 39510 1370 {lab=_102_}
N 39510 1370 39520 1370 {lab=_102_}
N 39510 1370 39510 1320 {lab=_102_}
N 39110 360 39120 360 {lab=_102_}
N 39510 1320 40520 1320 {lab=_102_}
N 40520 1320 40720 1320 {lab=_102_}
N 40520 1320 40520 1220 {lab=_102_}
N 40520 1220 40630 1220 {lab=_102_}
N 40630 1220 40630 250 {lab=_102_}
N 40630 1220 40640 1220 {lab=_102_}
N 40720 1320 40720 1370 {lab=_102_}
N 40720 1370 40980 1370 {lab=_102_}
N 40980 1370 41000 1370 {lab=_102_}
N 40980 1370 40980 1320 {lab=_102_}
N 40630 250 40720 250 {lab=_102_}
N 40630 250 40630 210 {lab=_102_}
N 40630 210 40640 210 {lab=_102_}
N 40720 250 40720 60 {lab=_102_}
N 40720 60 41000 60 {lab=_102_}
N 40980 1320 48510 1320 {lab=_102_}
N 48510 1320 48510 210 {lab=_102_}
N 48510 1320 48600 1320 {lab=_102_}
N 48600 1320 48600 1370 {lab=_102_}
N 48600 1370 48710 1370 {lab=_102_}
N 48710 1370 48710 1440 {lab=_102_}
N 48710 1370 48720 1370 {lab=_102_}
N 48510 210 48520 210 {lab=_102_}
N 48710 1440 56350 1440 {lab=_102_}
N 56350 1440 56350 590 {lab=_102_}
N 56350 1440 56440 1440 {lab=_102_}
N 56440 1440 56440 1370 {lab=_102_}
N 56440 1370 56560 1370 {lab=_102_}
N 56350 590 64900 590 {lab=_102_}
N 56350 590 56350 210 {lab=_102_}
N 56350 210 56360 210 {lab=_102_}
N 35400 1340 35400 1310 {lab=_099_}
N 35400 1310 37320 1310 {lab=_099_}
N 35400 1310 35400 90 {lab=_099_}
N 37320 1310 37320 1370 {lab=_099_}
N 37320 1370 37590 1370 {lab=_099_}
N 37590 1370 37600 1370 {lab=_099_}
N 37590 1370 37590 1320 {lab=_099_}
N 37590 1320 37680 1320 {lab=_099_}
N 37590 1320 37590 100 {lab=_099_}
N 37680 1320 37680 1370 {lab=_099_}
N 37680 1370 38340 1370 {lab=_099_}
N 38340 1370 38340 1450 {lab=_099_}
N 38340 1370 38360 1370 {lab=_099_}
N 37590 100 37590 60 {lab=_099_}
N 37590 100 38080 100 {lab=_099_}
N 37590 60 37600 60 {lab=_099_}
N 38080 100 38080 60 {lab=_099_}
N 38080 60 38360 60 {lab=_099_}
N 38340 1450 40970 1450 {lab=_099_}
N 40970 1450 41080 1450 {lab=_099_}
N 40970 1450 40970 920 {lab=_099_}
N 41080 1450 41080 1370 {lab=_099_}
N 41080 1370 41200 1370 {lab=_099_}
N 40970 920 40970 210 {lab=_099_}
N 40970 920 47550 920 {lab=_099_}
N 40970 210 41000 210 {lab=_099_}
N 47550 920 47560 920 {lab=_099_}
N 47550 920 47550 880 {lab=_099_}
N 47550 880 48040 880 {lab=_099_}
N 48040 880 49720 880 {lab=_099_}
N 48040 880 48040 60 {lab=_099_}
N 48040 60 48160 60 {lab=_099_}
N 49720 880 49720 1220 {lab=_099_}
N 49720 1220 50190 1220 {lab=_099_}
N 50190 1220 50190 1180 {lab=_099_}
N 50190 1220 50200 1220 {lab=_099_}
N 50190 1180 54200 1180 {lab=_099_}
N 50190 1180 50190 60 {lab=_099_}
N 50190 60 50200 60 {lab=_099_}
N 54200 1180 54200 1370 {lab=_099_}
N 54200 1370 54460 1370 {lab=_099_}
N 54460 1370 54460 60 {lab=_099_}
N 54460 1370 54480 1370 {lab=_099_}
N 54460 60 54480 60 {lab=_099_}
N 13520 1340 13520 1180 {lab=_101_}
N 13520 1180 14480 1180 {lab=_101_}
N 13520 1180 13520 90 {lab=_101_}
N 14480 1180 14480 1220 {lab=_101_}
N 14480 1220 15870 1220 {lab=_101_}
N 15870 1220 15870 1260 {lab=_101_}
N 15870 1220 15880 1220 {lab=_101_}
N 15870 1260 15960 1260 {lab=_101_}
N 15960 1260 15960 1220 {lab=_101_}
N 15960 1220 16070 1220 {lab=_101_}
N 16070 1220 16070 100 {lab=_101_}
N 16070 1220 16630 1220 {lab=_101_}
N 16630 1220 16640 1220 {lab=_101_}
N 16630 1220 16630 1260 {lab=_101_}
N 16070 100 16070 60 {lab=_101_}
N 16070 100 16720 100 {lab=_101_}
N 16070 60 16080 60 {lab=_101_}
N 16720 100 16720 60 {lab=_101_}
N 16720 60 16840 60 {lab=_101_}
N 16630 1260 34520 1260 {lab=_101_}
N 34520 1260 34520 1220 {lab=_101_}
N 34520 1220 36470 1220 {lab=_101_}
N 36470 1220 36480 1220 {lab=_101_}
N 36470 1220 36470 1180 {lab=_101_}
N 36470 1180 36560 1180 {lab=_101_}
N 36560 1180 40720 1180 {lab=_101_}
N 36560 1180 36560 60 {lab=_101_}
N 36560 60 36680 60 {lab=_101_}
N 40720 1180 40720 1220 {lab=_101_}
N 40720 1220 41950 1220 {lab=_101_}
N 41950 1220 41960 1220 {lab=_101_}
N 41950 1220 41950 1180 {lab=_101_}
N 41950 1180 42040 1180 {lab=_101_}
N 42040 1180 42040 60 {lab=_101_}
N 42040 1180 47080 1180 {lab=_101_}
N 42040 60 42160 60 {lab=_101_}
N 47080 1180 47080 1220 {lab=_101_}
N 47080 1220 47550 1220 {lab=_101_}
N 47550 1220 47560 1220 {lab=_101_}
N 47550 1220 47550 1180 {lab=_101_}
N 47550 1180 47640 1180 {lab=_101_}
N 47640 1180 47640 550 {lab=_101_}
N 47640 550 47640 60 {lab=_101_}
N 47640 550 64900 550 {lab=_101_}
N 47640 60 47760 60 {lab=_101_}
N 33520 1370 33510 1370 {lab=state_1}
N 33510 1370 33510 1340 {lab=state_1}
N 33510 1370 33510 1430 {lab=state_1}
N 33510 1340 33510 100 {lab=state_1}
N 33510 1340 33200 1340 {lab=state_1}
N 33510 1430 33600 1430 {lab=state_1}
N 33600 1430 33600 1370 {lab=state_1}
N 33600 1370 33870 1370 {lab=state_1}
N 33870 1370 33880 1370 {lab=state_1}
N 33870 1370 33870 1430 {lab=state_1}
N 33510 100 33600 100 {lab=state_1}
N 33510 100 33510 90 {lab=state_1}
N 33510 90 33200 90 {lab=state_1}
N 33510 90 33510 60 {lab=state_1}
N 33510 60 33520 60 {lab=state_1}
N 33600 100 33600 60 {lab=state_1}
N 33600 60 33880 60 {lab=state_1}
N 33870 1430 35700 1430 {lab=state_1}
N 35700 1430 35700 1260 {lab=state_1}
N 35700 1430 35800 1430 {lab=state_1}
N 35800 1430 35800 1370 {lab=state_1}
N 35800 1370 35920 1370 {lab=state_1}
N 35700 1260 35700 210 {lab=state_1}
N 35700 1260 37120 1260 {lab=state_1}
N 35700 210 35720 210 {lab=state_1}
N 37120 1260 37120 1220 {lab=state_1}
N 37120 1220 37580 1220 {lab=state_1}
N 37580 1220 37600 1220 {lab=state_1}
N 37580 1220 37580 1170 {lab=state_1}
N 37580 1170 37680 1170 {lab=state_1}
N 37680 1170 37680 60 {lab=state_1}
N 37680 1170 54210 1170 {lab=state_1}
N 37680 60 37800 60 {lab=state_1}
N 54210 1170 54210 1220 {lab=state_1}
N 54210 1220 54470 1220 {lab=state_1}
N 54470 1220 54480 1220 {lab=state_1}
N 54470 1220 54470 1180 {lab=state_1}
N 54470 1180 54560 1180 {lab=state_1}
N 54560 1180 54560 1150 {lab=state_1}
N 54560 1150 64900 1150 {lab=state_1}
N 54560 1150 54560 60 {lab=state_1}
N 54560 60 54680 60 {lab=state_1}
N 37080 1190 37280 1190 {lab=_111_}
N 37080 1190 37080 250 {lab=_111_}
N 37280 1190 37280 1300 {lab=_111_}
N 37280 1300 37280 1340 {lab=_111_}
N 37280 1300 39870 1300 {lab=_111_}
N 37080 250 37280 250 {lab=_111_}
N 37080 250 37080 240 {lab=_111_}
N 37280 250 37280 240 {lab=_111_}
N 39870 1300 39870 60 {lab=_111_}
N 39870 1300 39960 1300 {lab=_111_}
N 39960 1300 39960 1370 {lab=_111_}
N 39960 1370 40070 1370 {lab=_111_}
N 40070 1370 40070 1440 {lab=_111_}
N 40070 1370 40080 1370 {lab=_111_}
N 39870 60 39880 60 {lab=_111_}
N 40070 1440 42040 1440 {lab=_111_}
N 42040 1440 42040 1370 {lab=_111_}
N 42040 1370 42510 1370 {lab=_111_}
N 42510 1370 42520 1370 {lab=_111_}
N 42510 1370 42510 1310 {lab=_111_}
N 42510 1310 43720 1310 {lab=_111_}
N 42510 1310 42510 360 {lab=_111_}
N 42510 360 43440 360 {lab=_111_}
N 42510 360 42510 210 {lab=_111_}
N 42510 210 42520 210 {lab=_111_}
N 43720 1310 47640 1310 {lab=_111_}
N 43720 1310 43720 1370 {lab=_111_}
N 43720 1370 43840 1370 {lab=_111_}
N 47640 1310 47640 1370 {lab=_111_}
N 47640 1370 48500 1370 {lab=_111_}
N 48500 1370 48520 1370 {lab=_111_}
N 48500 1370 48500 670 {lab=_111_}
N 48500 670 64900 670 {lab=_111_}
N 48500 670 48500 60 {lab=_111_}
N 48500 60 48520 60 {lab=_111_}
N 33560 1340 33560 1290 {lab=_098_}
N 33560 1290 38340 1290 {lab=_098_}
N 33560 1290 33560 90 {lab=_098_}
N 38340 1290 38440 1290 {lab=_098_}
N 38340 1290 38340 210 {lab=_098_}
N 38440 1290 38440 1370 {lab=_098_}
N 38440 1370 38550 1370 {lab=_098_}
N 38550 1370 38550 1460 {lab=_098_}
N 38550 1370 38560 1370 {lab=_098_}
N 38340 210 38360 210 {lab=_098_}
N 38550 1460 40960 1460 {lab=_098_}
N 40960 1460 40960 360 {lab=_098_}
N 40960 1460 41280 1460 {lab=_098_}
N 41280 1460 41280 1370 {lab=_098_}
N 41280 1370 41390 1370 {lab=_098_}
N 41390 1370 41400 1370 {lab=_098_}
N 41390 1370 41390 1300 {lab=_098_}
N 40960 360 41000 360 {lab=_098_}
N 41390 1300 50180 1300 {lab=_098_}
N 50180 1300 50180 210 {lab=_098_}
N 50180 1300 50280 1300 {lab=_098_}
N 50280 1300 50280 1220 {lab=_098_}
N 50280 1220 50390 1220 {lab=_098_}
N 50390 1220 50400 1220 {lab=_098_}
N 50390 1220 50390 1260 {lab=_098_}
N 50180 210 50200 210 {lab=_098_}
N 50390 1260 52230 1260 {lab=_098_}
N 52230 1260 52330 1260 {lab=_098_}
N 52230 1260 52230 210 {lab=_098_}
N 52330 1260 52330 1220 {lab=_098_}
N 52330 1220 52430 1220 {lab=_098_}
N 52430 1220 52440 1220 {lab=_098_}
N 52430 1220 52430 1260 {lab=_098_}
N 52230 210 52240 210 {lab=_098_}
N 52430 1260 55320 1260 {lab=_098_}
N 55320 1260 55320 1220 {lab=_098_}
N 55320 1220 55790 1220 {lab=_098_}
N 55790 1220 55790 1180 {lab=_098_}
N 55790 1220 55800 1220 {lab=_098_}
N 55790 1180 55880 1180 {lab=_098_}
N 55880 1180 55880 210 {lab=_098_}
N 55880 210 56000 210 {lab=_098_}
N 35360 1370 35350 1370 {lab=state_2}
N 35350 1370 35350 1340 {lab=state_2}
N 35350 1370 35350 1450 {lab=state_2}
N 35350 1340 35040 1340 {lab=state_2}
N 35350 1340 35350 100 {lab=state_2}
N 35350 1450 35710 1450 {lab=state_2}
N 35710 1450 35710 1470 {lab=state_2}
N 35710 1450 35710 1370 {lab=state_2}
N 35710 1370 35720 1370 {lab=state_2}
N 35350 100 35440 100 {lab=state_2}
N 35350 100 35350 90 {lab=state_2}
N 35350 90 35350 60 {lab=state_2}
N 35350 90 35040 90 {lab=state_2}
N 35350 60 35360 60 {lab=state_2}
N 35440 100 35440 60 {lab=state_2}
N 35440 60 35720 60 {lab=state_2}
N 35710 1470 51960 1470 {lab=state_2}
N 51960 1470 51960 1430 {lab=state_2}
N 51960 1430 51960 1220 {lab=state_2}
N 51960 1430 55320 1430 {lab=state_2}
N 51960 1220 52220 1220 {lab=state_2}
N 52220 1220 52240 1220 {lab=state_2}
N 52220 1220 52220 60 {lab=state_2}
N 52220 60 52240 60 {lab=state_2}
N 55320 1430 55320 1370 {lab=state_2}
N 55320 1370 55780 1370 {lab=state_2}
N 55780 1370 55800 1370 {lab=state_2}
N 55780 1370 55780 1170 {lab=state_2}
N 55780 1170 55780 210 {lab=state_2}
N 55780 1170 64900 1170 {lab=state_2}
N 55780 210 55800 210 {lab=state_2}
N 64900 1170 64900 1190 {lab=state_2}
N 38400 1340 38400 1320 {lab=_113_}
N 38400 1320 38600 1320 {lab=_113_}
N 38400 1320 38400 390 {lab=_113_}
N 38600 1320 38600 1340 {lab=_113_}
N 38600 1320 38800 1320 {lab=_113_}
N 38800 1320 38800 1340 {lab=_113_}
N 38800 1340 38840 1340 {lab=_113_}
N 38840 1340 38840 1370 {lab=_113_}
N 38840 1370 39100 1370 {lab=_113_}
N 39100 1370 39100 1310 {lab=_113_}
N 39100 1370 39120 1370 {lab=_113_}
N 38400 390 38440 390 {lab=_113_}
N 38440 390 38440 60 {lab=_113_}
N 38440 60 39120 60 {lab=_113_}
N 39100 1310 41680 1310 {lab=_113_}
N 41680 1310 41680 1370 {lab=_113_}
N 41680 1370 41940 1370 {lab=_113_}
N 41940 1370 41960 1370 {lab=_113_}
N 41940 1370 41940 1260 {lab=_113_}
N 41940 1260 41940 60 {lab=_113_}
N 41940 1260 49160 1260 {lab=_113_}
N 41940 60 41960 60 {lab=_113_}
N 49160 1260 49160 1220 {lab=_113_}
N 49160 1220 49630 1220 {lab=_113_}
N 49630 1220 49630 1180 {lab=_113_}
N 49630 1220 49640 1220 {lab=_113_}
N 49630 1180 49730 1180 {lab=_113_}
N 49730 1180 49730 710 {lab=_113_}
N 49730 710 49730 60 {lab=_113_}
N 49730 710 64900 710 {lab=_113_}
N 49730 60 49840 60 {lab=_113_}
N 39160 1340 39160 1320 {lab=_115_}
N 39160 1320 39360 1320 {lab=_115_}
N 39160 1320 39160 390 {lab=_115_}
N 39360 1320 39360 1340 {lab=_115_}
N 39360 1320 39360 1290 {lab=_115_}
N 39360 1290 39560 1290 {lab=_115_}
N 39560 1290 39560 1340 {lab=_115_}
N 39560 1340 39600 1340 {lab=_115_}
N 39600 1340 39600 1370 {lab=_115_}
N 39600 1370 39870 1370 {lab=_115_}
N 39870 1370 39870 1480 {lab=_115_}
N 39870 1370 39880 1370 {lab=_115_}
N 39160 390 39200 390 {lab=_115_}
N 39200 390 39200 210 {lab=_115_}
N 39200 210 39880 210 {lab=_115_}
N 39870 1480 42500 1480 {lab=_115_}
N 42500 1480 42600 1480 {lab=_115_}
N 42500 1480 42500 170 {lab=_115_}
N 42600 1480 42600 1440 {lab=_115_}
N 42600 1440 43520 1440 {lab=_115_}
N 42600 1440 42600 1370 {lab=_115_}
N 42600 1370 42720 1370 {lab=_115_}
N 43520 1440 43520 1370 {lab=_115_}
N 43520 1440 43520 1450 {lab=_115_}
N 43520 1370 43640 1370 {lab=_115_}
N 42500 170 42500 60 {lab=_115_}
N 42500 170 42600 170 {lab=_115_}
N 42500 60 42520 60 {lab=_115_}
N 42600 170 42600 210 {lab=_115_}
N 42600 210 43440 210 {lab=_115_}
N 43520 1450 64910 1450 {lab=_115_}
N 64910 1450 64910 750 {lab=_115_}
N 64910 750 64900 750 {lab=_115_}
N 41040 1340 41040 1300 {lab=_117_}
N 41040 1340 41090 1340 {lab=_117_}
N 41040 1300 41240 1300 {lab=_117_}
N 41040 1300 41040 540 {lab=_117_}
N 41240 1300 41240 1340 {lab=_117_}
N 41240 1300 41240 1290 {lab=_117_}
N 41240 1290 41440 1290 {lab=_117_}
N 41440 1290 41640 1290 {lab=_117_}
N 41440 1290 41440 1340 {lab=_117_}
N 41640 1290 44190 1290 {lab=_117_}
N 41640 1290 41640 1340 {lab=_117_}
N 44190 1290 44190 790 {lab=_117_}
N 44190 1290 44280 1290 {lab=_117_}
N 44280 1290 44280 1370 {lab=_117_}
N 44280 1370 44400 1370 {lab=_117_}
N 44190 790 44190 210 {lab=_117_}
N 44190 790 64900 790 {lab=_117_}
N 44190 210 44200 210 {lab=_117_}
N 41090 1340 41090 1490 {lab=_117_}
N 41090 1490 14590 1490 {lab=_117_}
N 14590 1490 14590 60 {lab=_117_}
N 14590 1490 14390 1490 {lab=_117_}
N 14390 1490 14390 1370 {lab=_117_}
N 14390 1370 14400 1370 {lab=_117_}
N 14590 60 14600 60 {lab=_117_}
N 37640 1040 37690 1040 {lab=_112_}
N 37640 1040 37640 110 {lab=_112_}
N 37640 110 37640 90 {lab=_112_}
N 37640 110 37840 110 {lab=_112_}
N 37840 110 38040 110 {lab=_112_}
N 37840 110 37840 90 {lab=_112_}
N 38040 110 38040 90 {lab=_112_}
N 37690 1040 37690 1220 {lab=_112_}
N 37690 1220 39860 1220 {lab=_112_}
N 39860 1220 39880 1220 {lab=_112_}
N 39860 1220 39860 1260 {lab=_112_}
N 39860 1260 39960 1260 {lab=_112_}
N 39960 1260 39960 1220 {lab=_112_}
N 39960 1220 40070 1220 {lab=_112_}
N 40070 1220 40070 250 {lab=_112_}
N 40070 1220 40430 1220 {lab=_112_}
N 40430 1220 40440 1220 {lab=_112_}
N 40430 1220 40430 1270 {lab=_112_}
N 40070 250 40070 210 {lab=_112_}
N 40070 250 40520 250 {lab=_112_}
N 40070 210 40080 210 {lab=_112_}
N 40520 250 40520 60 {lab=_112_}
N 40520 60 40640 60 {lab=_112_}
N 40430 1270 49740 1270 {lab=_112_}
N 49740 1270 49740 1070 {lab=_112_}
N 49740 1070 52790 1070 {lab=_112_}
N 52790 1070 52790 60 {lab=_112_}
N 52790 1070 52800 1070 {lab=_112_}
N 52790 60 52800 60 {lab=_112_}
N 49680 1190 49680 1160 {lab=_081_}
N 49680 1160 49680 100 {lab=_081_}
N 49680 1160 50480 1160 {lab=_081_}
N 49680 100 49680 90 {lab=_081_}
N 49680 100 49880 100 {lab=_081_}
N 50480 1160 50480 1220 {lab=_081_}
N 50480 1220 50750 1220 {lab=_081_}
N 50750 1220 50750 1270 {lab=_081_}
N 50750 1220 50760 1220 {lab=_081_}
N 49880 100 50480 100 {lab=_081_}
N 49880 100 49880 90 {lab=_081_}
N 50480 100 50480 60 {lab=_081_}
N 50480 60 50760 60 {lab=_081_}
N 50750 1270 52520 1270 {lab=_081_}
N 52520 1270 52520 1220 {lab=_081_}
N 52520 1220 52790 1220 {lab=_081_}
N 52790 1220 52800 1220 {lab=_081_}
N 52790 1220 52790 1160 {lab=_081_}
N 52790 1160 52890 1160 {lab=_081_}
N 52890 1160 54570 1160 {lab=_081_}
N 52890 1160 52890 60 {lab=_081_}
N 52890 60 53000 60 {lab=_081_}
N 54570 1160 54570 1220 {lab=_081_}
N 54570 1220 55230 1220 {lab=_081_}
N 55230 1220 55230 1180 {lab=_081_}
N 55230 1220 55240 1220 {lab=_081_}
N 55230 1180 55320 1180 {lab=_081_}
N 55320 1180 55320 60 {lab=_081_}
N 55320 60 55440 60 {lab=_081_}
N 47600 890 47650 890 {lab=_077_}
N 47600 890 47600 100 {lab=_077_}
N 47600 100 47800 100 {lab=_077_}
N 47600 100 47600 90 {lab=_077_}
N 47800 100 47800 90 {lab=_077_}
N 47800 100 48000 100 {lab=_077_}
N 48000 100 48200 100 {lab=_077_}
N 48000 100 48000 90 {lab=_077_}
N 48200 100 49160 100 {lab=_077_}
N 48200 100 48200 90 {lab=_077_}
N 47650 890 47650 1220 {lab=_077_}
N 47650 1220 49070 1220 {lab=_077_}
N 49070 1220 49070 1310 {lab=_077_}
N 49070 1220 49080 1220 {lab=_077_}
N 49160 100 49160 60 {lab=_077_}
N 49160 60 49280 60 {lab=_077_}
N 49070 1310 51400 1310 {lab=_077_}
N 51400 1310 51400 1370 {lab=_077_}
N 51400 1370 51670 1370 {lab=_077_}
N 51670 1370 51670 1320 {lab=_077_}
N 51670 1370 51680 1370 {lab=_077_}
N 51670 1320 51760 1320 {lab=_077_}
N 51760 1320 51760 60 {lab=_077_}
N 51760 60 51880 60 {lab=_077_}
N 2040 1340 2040 1330 {lab=_031_}
N 2040 1330 2240 1330 {lab=_031_}
N 2040 1330 2040 540 {lab=_031_}
N 2240 1330 2240 1340 {lab=_031_}
N 2240 1330 2440 1330 {lab=_031_}
N 2440 1330 2440 1340 {lab=_031_}
N 2440 1330 2640 1330 {lab=_031_}
N 2640 1330 2640 1340 {lab=_031_}
N 2640 1340 2680 1340 {lab=_031_}
N 2680 1340 2680 1370 {lab=_031_}
N 2680 1370 2950 1370 {lab=_031_}
N 2950 1370 2960 1370 {lab=_031_}
N 2950 1370 2950 60 {lab=_031_}
N 2950 60 2950 0 {lab=_031_}
N 2950 60 2960 60 {lab=_031_}
N 2950 0 64900 0 {lab=_031_}
N 64900 0 64900 350 {lab=_031_}
N 7160 1340 7160 1330 {lab=280.ncki}
N 7160 1330 7160 90 {lab=280.ncki}
N 7160 1330 10800 1330 {lab=280.ncki}
N 10800 1330 10800 1370 {lab=280.ncki}
N 10800 1370 11070 1370 {lab=280.ncki}
N 11070 1370 11070 1500 {lab=280.ncki}
N 11070 1370 11080 1370 {lab=280.ncki}
N 11070 1370 11070 60 {lab=280.ncki}
N 11070 60 11080 60 {lab=280.ncki}
N 11070 1500 63240 1500 {lab=280.ncki}
N 63240 1500 63240 1220 {lab=280.ncki}
N 63240 1220 63510 1220 {lab=280.ncki}
N 63510 1220 63510 1260 {lab=280.ncki}
N 63510 1220 63520 1220 {lab=280.ncki}
N 63510 1260 63910 1260 {lab=280.ncki}
N 63910 1260 63910 250 {lab=280.ncki}
N 63910 1260 64360 1260 {lab=280.ncki}
N 64360 1260 64360 1220 {lab=280.ncki}
N 64360 1220 64480 1220 {lab=280.ncki}
N 63910 250 63910 210 {lab=280.ncki}
N 63910 250 64000 250 {lab=280.ncki}
N 63910 210 63920 210 {lab=280.ncki}
N 64000 250 64000 210 {lab=280.ncki}
N 64000 210 64280 210 {lab=280.ncki}
N 6800 1340 6800 1320 {lab=279.ncki}
N 6800 1320 10440 1320 {lab=279.ncki}
N 6800 1320 6800 90 {lab=279.ncki}
N 10440 1320 10440 1370 {lab=279.ncki}
N 10440 1370 10710 1370 {lab=279.ncki}
N 10710 1370 10720 1370 {lab=279.ncki}
N 10710 1370 10710 1510 {lab=279.ncki}
N 10710 1370 10710 60 {lab=279.ncki}
N 10710 60 10720 60 {lab=279.ncki}
N 10710 1510 61920 1510 {lab=279.ncki}
N 61920 1510 61920 1220 {lab=279.ncki}
N 61920 1220 62190 1220 {lab=279.ncki}
N 62190 1220 62190 1260 {lab=279.ncki}
N 62190 1220 62200 1220 {lab=279.ncki}
N 62190 1260 62580 1260 {lab=279.ncki}
N 62580 1260 62580 250 {lab=279.ncki}
N 62580 1260 63040 1260 {lab=279.ncki}
N 63040 1260 63040 1220 {lab=279.ncki}
N 63040 1220 63160 1220 {lab=279.ncki}
N 62580 250 62580 210 {lab=279.ncki}
N 62580 250 62680 250 {lab=279.ncki}
N 62580 210 62600 210 {lab=279.ncki}
N 62680 250 62680 210 {lab=279.ncki}
N 62680 210 62960 210 {lab=279.ncki}
N 6440 1340 6440 1310 {lab=278.ncki}
N 6440 1310 6440 90 {lab=278.ncki}
N 6440 1310 10080 1310 {lab=278.ncki}
N 10080 1310 10080 1370 {lab=278.ncki}
N 10080 1370 10350 1370 {lab=278.ncki}
N 10350 1370 10350 60 {lab=278.ncki}
N 10350 1370 10350 1520 {lab=278.ncki}
N 10350 1370 10360 1370 {lab=278.ncki}
N 10350 60 10360 60 {lab=278.ncki}
N 10350 1520 60600 1520 {lab=278.ncki}
N 60600 1520 60600 1220 {lab=278.ncki}
N 60600 1220 60870 1220 {lab=278.ncki}
N 60870 1220 60880 1220 {lab=278.ncki}
N 60870 1220 60870 1260 {lab=278.ncki}
N 60870 1260 61260 1260 {lab=278.ncki}
N 61260 1260 61720 1260 {lab=278.ncki}
N 61260 1260 61260 250 {lab=278.ncki}
N 61720 1260 61720 1220 {lab=278.ncki}
N 61720 1220 61840 1220 {lab=278.ncki}
N 61260 250 61360 250 {lab=278.ncki}
N 61260 250 61260 210 {lab=278.ncki}
N 61260 210 61280 210 {lab=278.ncki}
N 61360 250 61360 210 {lab=278.ncki}
N 61360 210 61640 210 {lab=278.ncki}
N 6080 1340 6080 1300 {lab=258.ncki}
N 6080 1300 9720 1300 {lab=258.ncki}
N 6080 1300 6080 90 {lab=258.ncki}
N 9720 1300 9720 1370 {lab=258.ncki}
N 9720 1370 9990 1370 {lab=258.ncki}
N 9990 1370 9990 60 {lab=258.ncki}
N 9990 1370 9990 1530 {lab=258.ncki}
N 9990 1370 10000 1370 {lab=258.ncki}
N 9990 60 10000 60 {lab=258.ncki}
N 9990 1530 59280 1530 {lab=258.ncki}
N 59280 1530 59280 1220 {lab=258.ncki}
N 59280 1220 59550 1220 {lab=258.ncki}
N 59550 1220 59550 1260 {lab=258.ncki}
N 59550 1220 59560 1220 {lab=258.ncki}
N 59550 1260 59940 1260 {lab=258.ncki}
N 59940 1260 59940 250 {lab=258.ncki}
N 59940 1260 60400 1260 {lab=258.ncki}
N 60400 1260 60400 1220 {lab=258.ncki}
N 60400 1220 60520 1220 {lab=258.ncki}
N 59940 250 59940 210 {lab=258.ncki}
N 59940 250 60040 250 {lab=258.ncki}
N 59940 210 59960 210 {lab=258.ncki}
N 60040 250 60040 210 {lab=258.ncki}
N 60040 210 60320 210 {lab=258.ncki}
N 5720 1340 5720 1320 {lab=257.ncki}
N 5720 1320 5770 1320 {lab=257.ncki}
N 5720 1320 5720 90 {lab=257.ncki}
N 5770 1320 5770 1430 {lab=257.ncki}
N 5770 1430 9360 1430 {lab=257.ncki}
N 9360 1430 9360 1370 {lab=257.ncki}
N 9360 1370 9630 1370 {lab=257.ncki}
N 9630 1370 9630 1540 {lab=257.ncki}
N 9630 1370 9640 1370 {lab=257.ncki}
N 9630 1370 9630 60 {lab=257.ncki}
N 9630 60 9640 60 {lab=257.ncki}
N 9630 1540 57960 1540 {lab=257.ncki}
N 57960 1540 57960 1220 {lab=257.ncki}
N 57960 1220 58230 1220 {lab=257.ncki}
N 58230 1220 58230 1260 {lab=257.ncki}
N 58230 1220 58240 1220 {lab=257.ncki}
N 58230 1260 58620 1260 {lab=257.ncki}
N 58620 1260 58620 250 {lab=257.ncki}
N 58620 1260 59080 1260 {lab=257.ncki}
N 59080 1260 59080 1220 {lab=257.ncki}
N 59080 1220 59200 1220 {lab=257.ncki}
N 58620 250 58620 210 {lab=257.ncki}
N 58620 250 58720 250 {lab=257.ncki}
N 58620 210 58640 210 {lab=257.ncki}
N 58720 250 58720 210 {lab=257.ncki}
N 58720 210 59000 210 {lab=257.ncki}
N 5360 1340 5360 1320 {lab=256.ncki}
N 5360 1320 5410 1320 {lab=256.ncki}
N 5360 1320 5360 90 {lab=256.ncki}
N 5410 1320 5410 1440 {lab=256.ncki}
N 5410 1440 9000 1440 {lab=256.ncki}
N 9000 1440 9000 1370 {lab=256.ncki}
N 9000 1370 9270 1370 {lab=256.ncki}
N 9270 1370 9280 1370 {lab=256.ncki}
N 9270 1370 9270 60 {lab=256.ncki}
N 9270 1370 9270 1550 {lab=256.ncki}
N 9270 60 9280 60 {lab=256.ncki}
N 9270 1550 56640 1550 {lab=256.ncki}
N 56640 1550 56640 1220 {lab=256.ncki}
N 56640 1220 56910 1220 {lab=256.ncki}
N 56910 1220 56920 1220 {lab=256.ncki}
N 56910 1220 56910 1260 {lab=256.ncki}
N 56910 1260 57300 1260 {lab=256.ncki}
N 57300 1260 57760 1260 {lab=256.ncki}
N 57300 1260 57300 250 {lab=256.ncki}
N 57760 1260 57760 1220 {lab=256.ncki}
N 57760 1220 57880 1220 {lab=256.ncki}
N 57300 250 57400 250 {lab=256.ncki}
N 57300 250 57300 210 {lab=256.ncki}
N 57300 210 57320 210 {lab=256.ncki}
N 57400 250 57400 210 {lab=256.ncki}
N 57400 210 57680 210 {lab=256.ncki}
N 44240 1340 44240 1280 {lab=_034_}
N 44240 1280 39860 1280 {lab=_034_}
N 44240 1280 44440 1280 {lab=_034_}
N 44240 1280 44240 240 {lab=_034_}
N 44440 1280 44440 1340 {lab=_034_}
N 44240 240 44280 240 {lab=_034_}
N 44280 240 44280 -10 {lab=_034_}
N 44280 -10 64910 -10 {lab=_034_}
N 64910 -10 64910 390 {lab=_034_}
N 64910 390 64900 390 {lab=_034_}
N 39860 1280 39860 1480 {lab=_034_}
N 39860 1480 16630 1480 {lab=_034_}
N 16630 1480 16630 1430 {lab=_034_}
N 16630 1430 16620 1430 {lab=_034_}
N 16630 1430 16630 1370 {lab=_034_}
N 16630 1370 16640 1370 {lab=_034_}
N 16620 1430 15870 1430 {lab=_034_}
N 16620 1430 16620 110 {lab=_034_}
N 15870 1430 15870 1370 {lab=_034_}
N 15870 1370 15880 1370 {lab=_034_}
N 16620 110 15870 110 {lab=_034_}
N 16620 110 16620 60 {lab=_034_}
N 16620 60 16640 60 {lab=_034_}
N 15870 110 15870 60 {lab=_034_}
N 15870 60 15880 60 {lab=_034_}
N 37040 1220 37030 1220 {lab=start_sync_1}
N 37030 1220 37030 1170 {lab=start_sync_1}
N 37030 1220 37030 1460 {lab=start_sync_1}
N 37030 1170 37120 1170 {lab=start_sync_1}
N 37120 1170 37120 1030 {lab=start_sync_1}
N 37120 1030 37120 210 {lab=start_sync_1}
N 37120 1030 37700 1030 {lab=start_sync_1}
N 37120 210 37240 210 {lab=start_sync_1}
N 37700 1030 37700 1070 {lab=start_sync_1}
N 37700 1070 47540 1070 {lab=start_sync_1}
N 47540 1070 47560 1070 {lab=start_sync_1}
N 47540 1070 47540 540 {lab=start_sync_1}
N 37030 1460 25590 1460 {lab=start_sync_1}
N 25590 1460 25590 1370 {lab=start_sync_1}
N 25590 1370 25600 1370 {lab=start_sync_1}
N 25590 1370 25590 1340 {lab=start_sync_1}
N 25590 1340 25590 90 {lab=start_sync_1}
N 25590 1340 25280 1340 {lab=start_sync_1}
N 47540 540 47840 540 {lab=start_sync_1}
N 47840 540 47840 60 {lab=start_sync_1}
N 47840 60 47960 60 {lab=start_sync_1}
N 25590 90 25280 90 {lab=start_sync_1}
N 25590 90 25590 60 {lab=start_sync_1}
N 25590 60 25600 60 {lab=start_sync_1}
N 5000 1340 5000 1320 {lab=255.ncki}
N 5000 1320 5000 90 {lab=255.ncki}
N 5000 1320 5050 1320 {lab=255.ncki}
N 5050 1320 5050 1450 {lab=255.ncki}
N 5050 1450 8640 1450 {lab=255.ncki}
N 8640 1450 8640 1370 {lab=255.ncki}
N 8640 1370 8910 1370 {lab=255.ncki}
N 8910 1370 8910 1170 {lab=255.ncki}
N 8910 1370 8920 1370 {lab=255.ncki}
N 8910 1170 24960 1170 {lab=255.ncki}
N 8910 1170 8910 60 {lab=255.ncki}
N 8910 60 8920 60 {lab=255.ncki}
N 24960 1170 24960 1220 {lab=255.ncki}
N 24960 1220 25580 1220 {lab=255.ncki}
N 25580 1220 25600 1220 {lab=255.ncki}
N 25580 1220 25580 1180 {lab=255.ncki}
N 25580 1180 25680 1180 {lab=255.ncki}
N 25680 1180 26910 1180 {lab=255.ncki}
N 25680 1180 25680 210 {lab=255.ncki}
N 25680 210 26000 210 {lab=255.ncki}
N 26910 1180 26910 210 {lab=255.ncki}
N 26910 1180 27000 1180 {lab=255.ncki}
N 27000 1180 27000 1220 {lab=255.ncki}
N 27000 1220 27120 1220 {lab=255.ncki}
N 26910 210 26920 210 {lab=255.ncki}
N 4640 1340 4640 1320 {lab=254.ncki}
N 4640 1320 4640 90 {lab=254.ncki}
N 4640 1320 4690 1320 {lab=254.ncki}
N 4690 1320 4690 1460 {lab=254.ncki}
N 4690 1460 8280 1460 {lab=254.ncki}
N 8280 1460 8280 1370 {lab=254.ncki}
N 8280 1370 8550 1370 {lab=254.ncki}
N 8550 1370 8560 1370 {lab=254.ncki}
N 8550 1370 8550 1270 {lab=254.ncki}
N 8550 1270 8550 60 {lab=254.ncki}
N 8550 1270 22720 1270 {lab=254.ncki}
N 8550 60 8560 60 {lab=254.ncki}
N 22720 1270 22720 1220 {lab=254.ncki}
N 22720 1220 23350 1220 {lab=254.ncki}
N 23350 1220 23350 1180 {lab=254.ncki}
N 23350 1220 23360 1220 {lab=254.ncki}
N 23350 1180 23440 1180 {lab=254.ncki}
N 23440 1180 23440 210 {lab=254.ncki}
N 23440 1180 24670 1180 {lab=254.ncki}
N 23440 210 23760 210 {lab=254.ncki}
N 24670 1180 24670 210 {lab=254.ncki}
N 24670 1180 24760 1180 {lab=254.ncki}
N 24760 1180 24760 1220 {lab=254.ncki}
N 24760 1220 24880 1220 {lab=254.ncki}
N 24670 210 24680 210 {lab=254.ncki}
N 44800 1190 44800 100 {lab=_035_}
N 44800 1190 44840 1190 {lab=_035_}
N 44840 1190 44840 1370 {lab=_035_}
N 44840 1370 45310 1370 {lab=_035_}
N 45310 1370 45310 1440 {lab=_035_}
N 45310 1370 45320 1370 {lab=_035_}
N 44800 100 45000 100 {lab=_035_}
N 44800 100 44800 90 {lab=_035_}
N 45000 100 45000 90 {lab=_035_}
N 45000 90 45040 90 {lab=_035_}
N 45040 90 45040 60 {lab=_035_}
N 45040 60 45310 60 {lab=_035_}
N 45310 60 45310 100 {lab=_035_}
N 45310 60 45320 60 {lab=_035_}
N 45310 1440 45960 1440 {lab=_035_}
N 45960 1440 45960 1370 {lab=_035_}
N 45960 1370 46440 1370 {lab=_035_}
N 45310 100 46160 100 {lab=_035_}
N 46160 100 46160 60 {lab=_035_}
N 46160 60 46430 60 {lab=_035_}
N 46430 60 46430 -20 {lab=_035_}
N 46430 60 46440 60 {lab=_035_}
N 46430 -20 64920 -20 {lab=_035_}
N 64920 -20 64920 430 {lab=_035_}
N 64920 430 64900 430 {lab=_035_}
N 4280 1340 4280 1290 {lab=253.ncki}
N 4280 1290 4280 90 {lab=253.ncki}
N 4280 1290 7920 1290 {lab=253.ncki}
N 7920 1290 7920 1370 {lab=253.ncki}
N 7920 1370 8190 1370 {lab=253.ncki}
N 8190 1370 8200 1370 {lab=253.ncki}
N 8190 1370 8190 1220 {lab=253.ncki}
N 8190 1220 8190 60 {lab=253.ncki}
N 8190 1220 12150 1220 {lab=253.ncki}
N 8190 60 8200 60 {lab=253.ncki}
N 12150 1220 12160 1220 {lab=253.ncki}
N 12150 1220 12150 1180 {lab=253.ncki}
N 12150 1180 12240 1180 {lab=253.ncki}
N 12240 1180 12240 1160 {lab=253.ncki}
N 12240 1160 12240 210 {lab=253.ncki}
N 12240 1160 22430 1160 {lab=253.ncki}
N 12240 210 12560 210 {lab=253.ncki}
N 22430 1160 22520 1160 {lab=253.ncki}
N 22430 1160 22430 210 {lab=253.ncki}
N 22520 1160 22520 1220 {lab=253.ncki}
N 22520 1220 22640 1220 {lab=253.ncki}
N 22430 210 22440 210 {lab=253.ncki}
N 32280 1340 32280 1310 {lab=_097_}
N 32280 1310 32280 90 {lab=_097_}
N 32280 1310 33870 1310 {lab=_097_}
N 33870 1310 33960 1310 {lab=_097_}
N 33870 1310 33870 1070 {lab=_097_}
N 33960 1310 33960 1370 {lab=_097_}
N 33960 1370 34080 1370 {lab=_097_}
N 33870 1070 33870 210 {lab=_097_}
N 33870 1070 37580 1070 {lab=_097_}
N 33870 210 33880 210 {lab=_097_}
N 37580 1070 37600 1070 {lab=_097_}
N 37580 1070 37580 1020 {lab=_097_}
N 37580 1020 37880 1020 {lab=_097_}
N 37880 1020 37880 60 {lab=_097_}
N 37880 1020 44450 1020 {lab=_097_}
N 37880 60 38000 60 {lab=_097_}
N 44450 1020 44450 1280 {lab=_097_}
N 44450 1280 49720 1280 {lab=_097_}
N 49720 1280 49720 1370 {lab=_097_}
N 49720 1370 50190 1370 {lab=_097_}
N 50190 1370 50200 1370 {lab=_097_}
N 50190 1370 50190 1320 {lab=_097_}
N 50190 1320 50290 1320 {lab=_097_}
N 50290 1320 50290 60 {lab=_097_}
N 50290 60 50400 60 {lab=_097_}
N 3920 1340 3920 1320 {lab=252.ncki}
N 3920 1320 3970 1320 {lab=252.ncki}
N 3920 1320 3920 90 {lab=252.ncki}
N 3970 1320 3970 1470 {lab=252.ncki}
N 3970 1470 7560 1470 {lab=252.ncki}
N 7560 1470 7560 1370 {lab=252.ncki}
N 7560 1370 7830 1370 {lab=252.ncki}
N 7830 1370 7830 1280 {lab=252.ncki}
N 7830 1370 7840 1370 {lab=252.ncki}
N 7830 1280 19000 1280 {lab=252.ncki}
N 7830 1280 7830 60 {lab=252.ncki}
N 7830 60 7840 60 {lab=252.ncki}
N 19000 1280 19000 1220 {lab=252.ncki}
N 19000 1220 19630 1220 {lab=252.ncki}
N 19630 1220 19640 1220 {lab=252.ncki}
N 19630 1220 19630 1180 {lab=252.ncki}
N 19630 1180 19720 1180 {lab=252.ncki}
N 19720 1180 19720 210 {lab=252.ncki}
N 19720 1180 20950 1180 {lab=252.ncki}
N 19720 210 20040 210 {lab=252.ncki}
N 20950 1180 20950 210 {lab=252.ncki}
N 20950 1180 21040 1180 {lab=252.ncki}
N 21040 1180 21040 1220 {lab=252.ncki}
N 21040 1220 21160 1220 {lab=252.ncki}
N 20950 210 20960 210 {lab=252.ncki}
N 3560 1340 3560 1320 {lab=251.ncki}
N 3560 1320 3560 90 {lab=251.ncki}
N 3560 1320 3610 1320 {lab=251.ncki}
N 3610 1320 3610 1480 {lab=251.ncki}
N 3610 1480 7200 1480 {lab=251.ncki}
N 7200 1480 7200 1370 {lab=251.ncki}
N 7200 1370 7470 1370 {lab=251.ncki}
N 7470 1370 7470 1150 {lab=251.ncki}
N 7470 1370 7480 1370 {lab=251.ncki}
N 7470 1150 7470 60 {lab=251.ncki}
N 7470 1150 16720 1150 {lab=251.ncki}
N 7470 60 7480 60 {lab=251.ncki}
N 16720 1150 16720 1220 {lab=251.ncki}
N 16720 1220 17390 1220 {lab=251.ncki}
N 17390 1220 17400 1220 {lab=251.ncki}
N 17390 1220 17390 1180 {lab=251.ncki}
N 17390 1180 17480 1180 {lab=251.ncki}
N 17480 1180 17480 210 {lab=251.ncki}
N 17480 1180 18710 1180 {lab=251.ncki}
N 17480 210 17800 210 {lab=251.ncki}
N 18710 1180 18800 1180 {lab=251.ncki}
N 18710 1180 18710 210 {lab=251.ncki}
N 18800 1180 18800 1220 {lab=251.ncki}
N 18800 1220 18920 1220 {lab=251.ncki}
N 18710 210 18720 210 {lab=251.ncki}
N 35760 1340 35760 1300 {lab=_109_}
N 35760 1300 35760 390 {lab=_109_}
N 35760 1300 35960 1300 {lab=_109_}
N 35960 1300 36160 1300 {lab=_109_}
N 35960 1300 35960 1340 {lab=_109_}
N 36160 1300 36160 1340 {lab=_109_}
N 36160 1340 36200 1340 {lab=_109_}
N 36200 1340 36200 1370 {lab=_109_}
N 36200 1370 36470 1370 {lab=_109_}
N 36470 1370 36470 1280 {lab=_109_}
N 36470 1370 36480 1370 {lab=_109_}
N 35760 390 35800 390 {lab=_109_}
N 35800 390 35800 60 {lab=_109_}
N 35800 60 36480 60 {lab=_109_}
N 36470 1280 39100 1280 {lab=_109_}
N 39100 1280 39200 1280 {lab=_109_}
N 39100 1280 39100 210 {lab=_109_}
N 39200 1280 39200 1370 {lab=_109_}
N 39200 1370 39320 1370 {lab=_109_}
N 39100 210 39120 210 {lab=_109_}
N 63160 1370 63150 1370 {lab=279.net4}
N 63150 1370 63150 60 {lab=279.net4}
N 63150 1370 63150 1560 {lab=279.net4}
N 63150 60 63160 60 {lab=279.net4}
N 63150 1560 33150 1560 {lab=279.net4}
N 33150 1560 33150 1370 {lab=279.net4}
N 33150 1370 33150 1190 {lab=279.net4}
N 33150 1370 33160 1370 {lab=279.net4}
N 33150 1190 32640 1190 {lab=279.net4}
N 33150 1190 33150 90 {lab=279.net4}
N 33150 90 32840 90 {lab=279.net4}
N 33150 90 33150 60 {lab=279.net4}
N 33150 60 33160 60 {lab=279.net4}
N 32840 90 32840 100 {lab=279.net4}
N 32840 100 32640 100 {lab=279.net4}
N 32640 100 32640 90 {lab=279.net4}
N 61840 1370 61830 1370 {lab=278.net4}
N 61830 1370 61830 60 {lab=278.net4}
N 61830 1370 61830 1570 {lab=278.net4}
N 61830 60 61840 60 {lab=278.net4}
N 61830 1570 31870 1570 {lab=278.net4}
N 31870 1570 31870 1370 {lab=278.net4}
N 31870 1370 31880 1370 {lab=278.net4}
N 31870 1370 31870 1190 {lab=278.net4}
N 31870 1190 31360 1190 {lab=278.net4}
N 31870 1190 31870 90 {lab=278.net4}
N 31870 90 31560 90 {lab=278.net4}
N 31870 90 31870 60 {lab=278.net4}
N 31870 60 31880 60 {lab=278.net4}
N 31560 90 31560 100 {lab=278.net4}
N 31560 100 31360 100 {lab=278.net4}
N 31360 100 31360 90 {lab=278.net4}
N 60520 1370 60510 1370 {lab=258.net4}
N 60510 1370 60510 1580 {lab=258.net4}
N 60510 1370 60510 60 {lab=258.net4}
N 60510 60 60520 60 {lab=258.net4}
N 60510 1580 30950 1580 {lab=258.net4}
N 30950 1580 30950 1370 {lab=258.net4}
N 30950 1370 30950 1190 {lab=258.net4}
N 30950 1370 30960 1370 {lab=258.net4}
N 30950 1190 30440 1190 {lab=258.net4}
N 30950 1190 30950 90 {lab=258.net4}
N 30950 90 30640 90 {lab=258.net4}
N 30950 90 30950 60 {lab=258.net4}
N 30950 60 30960 60 {lab=258.net4}
N 30640 90 30640 110 {lab=258.net4}
N 30640 110 30440 110 {lab=258.net4}
N 30440 110 30440 90 {lab=258.net4}
N 64480 1370 64470 1370 {lab=280.net4}
N 64470 1370 64470 1590 {lab=280.net4}
N 64470 1370 64470 60 {lab=280.net4}
N 64470 60 64480 60 {lab=280.net4}
N 64470 1590 34990 1590 {lab=280.net4}
N 34990 1590 34990 1370 {lab=280.net4}
N 34990 1370 35000 1370 {lab=280.net4}
N 34990 1370 34990 1190 {lab=280.net4}
N 34990 1190 34480 1190 {lab=280.net4}
N 34990 1190 34990 90 {lab=280.net4}
N 34990 90 34990 60 {lab=280.net4}
N 34990 90 34680 90 {lab=280.net4}
N 34990 60 35000 60 {lab=280.net4}
N 34680 90 34680 100 {lab=280.net4}
N 34680 100 34480 100 {lab=280.net4}
N 34480 100 34480 90 {lab=280.net4}
N 59200 1370 59190 1370 {lab=257.net4}
N 59190 1370 59190 60 {lab=257.net4}
N 59190 1370 59190 1600 {lab=257.net4}
N 59190 60 59200 60 {lab=257.net4}
N 59190 1600 30030 1600 {lab=257.net4}
N 30030 1600 30030 1370 {lab=257.net4}
N 30030 1370 30030 1190 {lab=257.net4}
N 30030 1370 30040 1370 {lab=257.net4}
N 30030 1190 30030 90 {lab=257.net4}
N 30030 1190 29520 1190 {lab=257.net4}
N 30030 90 29720 90 {lab=257.net4}
N 30030 90 30030 60 {lab=257.net4}
N 30030 60 30040 60 {lab=257.net4}
N 29720 90 29720 110 {lab=257.net4}
N 29720 110 29520 110 {lab=257.net4}
N 29520 110 29520 90 {lab=257.net4}
N 42000 1190 42040 1190 {lab=_118_}
N 42000 1190 42000 100 {lab=_118_}
N 42000 100 42200 100 {lab=_118_}
N 42000 100 42000 90 {lab=_118_}
N 42200 100 42200 90 {lab=_118_}
N 42040 1190 42040 1220 {lab=_118_}
N 42040 1220 42050 1220 {lab=_118_}
N 42050 1220 42050 1610 {lab=_118_}
N 42050 1220 44750 1220 {lab=_118_}
N 44750 1220 44760 1220 {lab=_118_}
N 44750 1220 44750 1160 {lab=_118_}
N 44750 1160 44840 1160 {lab=_118_}
N 44840 1160 44840 60 {lab=_118_}
N 44840 60 44960 60 {lab=_118_}
N 42050 1610 15310 1610 {lab=_118_}
N 15310 1610 15310 1370 {lab=_118_}
N 15310 1370 15320 1370 {lab=_118_}
N 15310 1370 15310 60 {lab=_118_}
N 15310 60 15320 60 {lab=_118_}
N 57880 1370 57870 1370 {lab=256.net4}
N 57870 1370 57870 1620 {lab=256.net4}
N 57870 1370 57870 60 {lab=256.net4}
N 57870 60 57880 60 {lab=256.net4}
N 57870 1620 28750 1620 {lab=256.net4}
N 28750 1620 28750 1370 {lab=256.net4}
N 28750 1370 28760 1370 {lab=256.net4}
N 28750 1370 28750 1190 {lab=256.net4}
N 28750 1190 28750 90 {lab=256.net4}
N 28750 1190 28240 1190 {lab=256.net4}
N 28750 90 28750 60 {lab=256.net4}
N 28750 90 28440 90 {lab=256.net4}
N 28750 60 28760 60 {lab=256.net4}
N 28440 90 28440 100 {lab=256.net4}
N 28440 100 28240 100 {lab=256.net4}
N 28240 100 28240 90 {lab=256.net4}
N 43480 1340 43480 390 {lab=_122_}
N 43480 1340 43530 1340 {lab=_122_}
N 43530 1340 43530 1440 {lab=_122_}
N 43530 1440 43730 1440 {lab=_122_}
N 43730 1440 43730 1340 {lab=_122_}
N 43730 1440 43920 1440 {lab=_122_}
N 43730 1340 43680 1340 {lab=_122_}
N 43920 1440 43920 1340 {lab=_122_}
N 43920 1440 44480 1440 {lab=_122_}
N 43920 1340 43880 1340 {lab=_122_}
N 43480 390 44290 390 {lab=_122_}
N 44480 1440 44480 1370 {lab=_122_}
N 44480 1370 44760 1370 {lab=_122_}
N 44290 390 44290 60 {lab=_122_}
N 44290 60 44750 60 {lab=_122_}
N 44750 60 44750 -30 {lab=_122_}
N 44750 60 44760 60 {lab=_122_}
N 44750 -30 64930 -30 {lab=_122_}
N 64930 -30 64930 910 {lab=_122_}
N 64930 910 64900 910 {lab=_122_}
N 14400 1220 14390 1220 {lab=reference_fault}
N 14390 1220 14390 210 {lab=reference_fault}
N 14390 1220 14390 1260 {lab=reference_fault}
N 14390 210 14390 60 {lab=reference_fault}
N 14390 210 15320 210 {lab=reference_fault}
N 14390 60 14400 60 {lab=reference_fault}
N 14390 1260 14380 1260 {lab=reference_fault}
N 14390 1260 15400 1260 {lab=reference_fault}
N 15400 1260 15400 1370 {lab=reference_fault}
N 15400 1370 15520 1370 {lab=reference_fault}
N 14380 1260 14380 1490 {lab=reference_fault}
N 14380 1490 3150 1490 {lab=reference_fault}
N 3150 1490 3150 1370 {lab=reference_fault}
N 3150 1370 3160 1370 {lab=reference_fault}
N 3150 1370 3150 1330 {lab=reference_fault}
N 3150 1330 2940 1330 {lab=reference_fault}
N 2940 1330 2940 570 {lab=reference_fault}
N 2940 570 2940 210 {lab=reference_fault}
N 2940 570 -60 570 {lab=reference_fault}
N 2940 210 2960 210 {lab=reference_fault}
N 54520 1040 54520 100 {lab=_086_}
N 54520 1040 54580 1040 {lab=_086_}
N 54520 100 54720 100 {lab=_086_}
N 54520 100 54520 90 {lab=_086_}
N 54580 1040 54580 1370 {lab=_086_}
N 54580 1370 55240 1370 {lab=_086_}
N 54720 100 54720 90 {lab=_086_}
N 54720 100 54920 100 {lab=_086_}
N 54920 100 54920 90 {lab=_086_}
N 54920 90 54960 90 {lab=_086_}
N 54960 90 54960 60 {lab=_086_}
N 54960 60 55230 60 {lab=_086_}
N 55230 60 55230 110 {lab=_086_}
N 55230 60 55240 60 {lab=_086_}
N 55230 110 64360 110 {lab=_086_}
N 64360 110 64360 470 {lab=_086_}
N 64360 470 64900 470 {lab=_086_}
N 49120 1190 49120 1150 {lab=_079_}
N 49120 1150 49120 110 {lab=_079_}
N 49120 1150 51670 1150 {lab=_079_}
N 49120 110 49120 90 {lab=_079_}
N 49120 110 49320 110 {lab=_079_}
N 49320 110 49320 90 {lab=_079_}
N 51670 1150 51670 210 {lab=_079_}
N 51670 1150 51770 1150 {lab=_079_}
N 51770 1150 51770 1220 {lab=_079_}
N 51770 1220 51870 1220 {lab=_079_}
N 51870 1220 51870 1280 {lab=_079_}
N 51870 1220 51880 1220 {lab=_079_}
N 51670 210 51680 210 {lab=_079_}
N 51870 1280 53910 1280 {lab=_079_}
N 53910 1280 53910 210 {lab=_079_}
N 53910 1280 54000 1280 {lab=_079_}
N 54000 1280 54000 1370 {lab=_079_}
N 54000 1370 54120 1370 {lab=_079_}
N 53910 210 53920 210 {lab=_079_}
N 160 890 1990 890 {lab=_029_}
N 160 890 160 100 {lab=_029_}
N 160 100 160 90 {lab=_029_}
N 160 100 360 100 {lab=_029_}
N 360 100 560 100 {lab=_029_}
N 360 100 360 90 {lab=_029_}
N 560 100 760 100 {lab=_029_}
N 560 100 560 90 {lab=_029_}
N 760 100 760 90 {lab=_029_}
N 1990 890 2080 890 {lab=_029_}
N 1990 890 1990 210 {lab=_029_}
N 2080 890 2080 1370 {lab=_029_}
N 2080 1370 2200 1370 {lab=_029_}
N 1990 210 2000 210 {lab=_029_}
N 18920 1370 18910 1370 {lab=251.net4}
N 18910 1370 18910 1320 {lab=251.net4}
N 18910 1370 18910 1430 {lab=251.net4}
N 18910 1430 19000 1430 {lab=251.net4}
N 19000 1430 19000 1370 {lab=251.net4}
N 19000 1370 19280 1370 {lab=251.net4}
N 18910 1320 18710 1320 {lab=251.net4}
N 18910 1320 18910 100 {lab=251.net4}
N 18710 1320 18710 1190 {lab=251.net4}
N 18710 1190 18200 1190 {lab=251.net4}
N 18910 100 18910 60 {lab=251.net4}
N 18910 100 19000 100 {lab=251.net4}
N 18910 100 18400 100 {lab=251.net4}
N 18910 60 18920 60 {lab=251.net4}
N 19000 100 19000 60 {lab=251.net4}
N 19000 60 19280 60 {lab=251.net4}
N 18400 100 18400 90 {lab=251.net4}
N 18400 100 18200 100 {lab=251.net4}
N 18200 100 18200 90 {lab=251.net4}
N 21160 1370 21150 1370 {lab=252.net4}
N 21150 1370 21150 1430 {lab=252.net4}
N 21150 1370 21150 1320 {lab=252.net4}
N 21150 1430 21240 1430 {lab=252.net4}
N 21240 1430 21240 1370 {lab=252.net4}
N 21240 1370 21520 1370 {lab=252.net4}
N 21150 1320 20950 1320 {lab=252.net4}
N 21150 1320 21150 100 {lab=252.net4}
N 20950 1320 20950 1190 {lab=252.net4}
N 20950 1190 20440 1190 {lab=252.net4}
N 21150 100 21240 100 {lab=252.net4}
N 21150 100 21150 60 {lab=252.net4}
N 21150 100 20640 100 {lab=252.net4}
N 21150 60 21160 60 {lab=252.net4}
N 21240 100 21240 60 {lab=252.net4}
N 21240 60 21520 60 {lab=252.net4}
N 20640 100 20440 100 {lab=252.net4}
N 20640 100 20640 90 {lab=252.net4}
N 20440 100 20440 90 {lab=252.net4}
N 22640 1370 22630 1370 {lab=253.net4}
N 22630 1370 22630 1320 {lab=253.net4}
N 22630 1370 22630 1430 {lab=253.net4}
N 22630 1430 22720 1430 {lab=253.net4}
N 22720 1430 22720 1370 {lab=253.net4}
N 22720 1370 23000 1370 {lab=253.net4}
N 22630 1320 22430 1320 {lab=253.net4}
N 22630 1320 22630 100 {lab=253.net4}
N 22430 1320 22430 1190 {lab=253.net4}
N 22430 1190 21920 1190 {lab=253.net4}
N 22630 100 22630 60 {lab=253.net4}
N 22630 100 22720 100 {lab=253.net4}
N 22630 100 22120 100 {lab=253.net4}
N 22630 60 22640 60 {lab=253.net4}
N 22720 100 22720 60 {lab=253.net4}
N 22720 60 23000 60 {lab=253.net4}
N 22120 100 22120 90 {lab=253.net4}
N 22120 100 21920 100 {lab=253.net4}
N 21920 100 21920 90 {lab=253.net4}
N 24880 1370 24870 1370 {lab=254.net4}
N 24870 1370 24870 1320 {lab=254.net4}
N 24870 1370 24870 1430 {lab=254.net4}
N 24870 1430 24960 1430 {lab=254.net4}
N 24960 1430 24960 1370 {lab=254.net4}
N 24960 1370 25240 1370 {lab=254.net4}
N 24870 1320 24870 100 {lab=254.net4}
N 24870 1320 24670 1320 {lab=254.net4}
N 24670 1320 24670 1190 {lab=254.net4}
N 24670 1190 24160 1190 {lab=254.net4}
N 24870 100 24960 100 {lab=254.net4}
N 24870 100 24870 60 {lab=254.net4}
N 24870 100 24360 100 {lab=254.net4}
N 24870 60 24880 60 {lab=254.net4}
N 24960 100 24960 60 {lab=254.net4}
N 24960 60 25240 60 {lab=254.net4}
N 24360 100 24160 100 {lab=254.net4}
N 24360 100 24360 90 {lab=254.net4}
N 24160 100 24160 90 {lab=254.net4}
N 27120 1370 27110 1370 {lab=255.net4}
N 27110 1370 27110 1430 {lab=255.net4}
N 27110 1370 27110 1320 {lab=255.net4}
N 27110 1430 27200 1430 {lab=255.net4}
N 27200 1430 27200 1370 {lab=255.net4}
N 27200 1370 27480 1370 {lab=255.net4}
N 27110 1320 26910 1320 {lab=255.net4}
N 27110 1320 27110 100 {lab=255.net4}
N 26910 1320 26910 1190 {lab=255.net4}
N 26910 1190 26400 1190 {lab=255.net4}
N 27110 100 27200 100 {lab=255.net4}
N 27110 100 27110 60 {lab=255.net4}
N 27110 100 26600 100 {lab=255.net4}
N 27110 60 27120 60 {lab=255.net4}
N 27200 100 27200 60 {lab=255.net4}
N 27200 60 27480 60 {lab=255.net4}
N 26600 100 26400 100 {lab=255.net4}
N 26600 100 26600 90 {lab=255.net4}
N 26400 100 26400 90 {lab=255.net4}
N 11120 1340 11120 90 {lab=280.cki}
N 11120 1340 11160 1340 {lab=280.cki}
N 11160 1340 11160 1630 {lab=280.cki}
N 11160 1630 63250 1630 {lab=280.cki}
N 63250 1630 63250 1070 {lab=280.cki}
N 63250 1070 63510 1070 {lab=280.cki}
N 63510 1070 63510 260 {lab=280.cki}
N 63510 1070 63710 1070 {lab=280.cki}
N 63710 1070 63720 1070 {lab=280.cki}
N 63710 1070 63710 1120 {lab=280.cki}
N 63710 1120 63800 1120 {lab=280.cki}
N 63800 1120 63800 1220 {lab=280.cki}
N 63800 1220 64280 1220 {lab=280.cki}
N 63510 260 64370 260 {lab=280.cki}
N 63510 260 63510 210 {lab=280.cki}
N 63510 210 63520 210 {lab=280.cki}
N 64370 260 64370 210 {lab=280.cki}
N 64370 210 64480 210 {lab=280.cki}
N 10760 1340 10760 1320 {lab=279.cki}
N 10760 1320 10810 1320 {lab=279.cki}
N 10760 1320 10760 90 {lab=279.cki}
N 10810 1320 10810 1640 {lab=279.cki}
N 10810 1640 61930 1640 {lab=279.cki}
N 61930 1640 61930 1070 {lab=279.cki}
N 61930 1070 62190 1070 {lab=279.cki}
N 62190 1070 62190 260 {lab=279.cki}
N 62190 1070 62390 1070 {lab=279.cki}
N 62390 1070 62390 1120 {lab=279.cki}
N 62390 1070 62400 1070 {lab=279.cki}
N 62390 1120 62480 1120 {lab=279.cki}
N 62480 1120 62480 1220 {lab=279.cki}
N 62480 1220 62960 1220 {lab=279.cki}
N 62190 260 62190 210 {lab=279.cki}
N 62190 260 63040 260 {lab=279.cki}
N 62190 210 62200 210 {lab=279.cki}
N 63040 260 63040 210 {lab=279.cki}
N 63040 210 63160 210 {lab=279.cki}
N 10400 1340 10400 90 {lab=278.cki}
N 10400 90 10440 90 {lab=278.cki}
N 10440 90 10440 -40 {lab=278.cki}
N 10440 -40 60600 -40 {lab=278.cki}
N 60600 -40 60600 210 {lab=278.cki}
N 60600 210 60600 1070 {lab=278.cki}
N 60600 210 60870 210 {lab=278.cki}
N 60600 1070 61070 1070 {lab=278.cki}
N 61070 1070 61070 1120 {lab=278.cki}
N 61070 1070 61080 1070 {lab=278.cki}
N 61070 1120 61160 1120 {lab=278.cki}
N 61160 1120 61160 1220 {lab=278.cki}
N 61160 1220 61640 1220 {lab=278.cki}
N 60870 210 60880 210 {lab=278.cki}
N 60870 210 60870 170 {lab=278.cki}
N 60870 170 61720 170 {lab=278.cki}
N 61720 170 61720 210 {lab=278.cki}
N 61720 210 61840 210 {lab=278.cki}
N 10040 1340 10040 90 {lab=258.cki}
N 10040 1340 10090 1340 {lab=258.cki}
N 10090 1340 10090 1650 {lab=258.cki}
N 10090 1650 59290 1650 {lab=258.cki}
N 59290 1650 59290 1070 {lab=258.cki}
N 59290 1070 59550 1070 {lab=258.cki}
N 59550 1070 59550 260 {lab=258.cki}
N 59550 1070 59750 1070 {lab=258.cki}
N 59750 1070 59760 1070 {lab=258.cki}
N 59750 1070 59750 1120 {lab=258.cki}
N 59750 1120 59840 1120 {lab=258.cki}
N 59840 1120 59840 1220 {lab=258.cki}
N 59840 1220 60320 1220 {lab=258.cki}
N 59550 260 60400 260 {lab=258.cki}
N 59550 260 59550 210 {lab=258.cki}
N 59550 210 59560 210 {lab=258.cki}
N 60400 260 60400 210 {lab=258.cki}
N 60400 210 60520 210 {lab=258.cki}
N 9680 1340 9680 90 {lab=257.cki}
N 9680 90 9720 90 {lab=257.cki}
N 9720 90 9720 -50 {lab=257.cki}
N 9720 -50 57960 -50 {lab=257.cki}
N 57960 -50 57960 210 {lab=257.cki}
N 57960 210 57960 1070 {lab=257.cki}
N 57960 210 58230 210 {lab=257.cki}
N 57960 1070 58430 1070 {lab=257.cki}
N 58430 1070 58430 1120 {lab=257.cki}
N 58430 1070 58440 1070 {lab=257.cki}
N 58430 1120 58520 1120 {lab=257.cki}
N 58520 1120 58520 1220 {lab=257.cki}
N 58520 1220 59000 1220 {lab=257.cki}
N 58230 210 58240 210 {lab=257.cki}
N 58230 210 58230 170 {lab=257.cki}
N 58230 170 59080 170 {lab=257.cki}
N 59080 170 59080 210 {lab=257.cki}
N 59080 210 59200 210 {lab=257.cki}
N 9320 1340 9320 90 {lab=256.cki}
N 9320 90 9360 90 {lab=256.cki}
N 9360 90 9360 -60 {lab=256.cki}
N 9360 -60 56080 -60 {lab=256.cki}
N 56080 -60 56080 170 {lab=256.cki}
N 56080 170 56440 170 {lab=256.cki}
N 56080 170 56080 1070 {lab=256.cki}
N 56080 1070 57110 1070 {lab=256.cki}
N 57110 1070 57110 1120 {lab=256.cki}
N 57110 1070 57120 1070 {lab=256.cki}
N 57110 1120 57200 1120 {lab=256.cki}
N 57200 1120 57200 1220 {lab=256.cki}
N 57200 1220 57680 1220 {lab=256.cki}
N 56440 170 56440 210 {lab=256.cki}
N 56440 210 56910 210 {lab=256.cki}
N 56910 210 56920 210 {lab=256.cki}
N 56910 210 56910 170 {lab=256.cki}
N 56910 170 57760 170 {lab=256.cki}
N 57760 170 57760 210 {lab=256.cki}
N 57760 210 57880 210 {lab=256.cki}
N 33920 1340 33920 1300 {lab=_103_}
N 33920 1300 33920 240 {lab=_103_}
N 33920 1300 34120 1300 {lab=_103_}
N 34120 1300 34120 1340 {lab=_103_}
N 34120 1300 34120 1270 {lab=_103_}
N 34120 1270 39970 1270 {lab=_103_}
N 39970 1270 39970 1260 {lab=_103_}
N 39970 1260 41290 1260 {lab=_103_}
N 41290 1260 41290 1460 {lab=_103_}
N 41290 1460 47080 1460 {lab=_103_}
N 47080 1460 47080 1370 {lab=_103_}
N 47080 1370 47530 1370 {lab=_103_}
N 47530 1370 47560 1370 {lab=_103_}
N 47530 1370 47530 60 {lab=_103_}
N 47530 60 47550 60 {lab=_103_}
N 47550 60 47550 -70 {lab=_103_}
N 47550 60 47560 60 {lab=_103_}
N 47550 -70 64940 -70 {lab=_103_}
N 64940 -70 64940 630 {lab=_103_}
N 64940 630 64900 630 {lab=_103_}
N 63000 1190 63000 1180 {lab=279.net8}
N 63000 1180 63000 270 {lab=279.net8}
N 63000 1180 63050 1180 {lab=279.net8}
N 63050 1180 63050 1660 {lab=279.net8}
N 63050 1180 63200 1180 {lab=279.net8}
N 63200 1180 63200 1190 {lab=279.net8}
N 63000 270 63200 270 {lab=279.net8}
N 63000 270 63000 240 {lab=279.net8}
N 63200 270 63200 240 {lab=279.net8}
N 63050 1660 32580 1660 {lab=279.net8}
N 32580 1660 32580 1220 {lab=279.net8}
N 32580 1220 32580 1180 {lab=279.net8}
N 32580 1220 32600 1220 {lab=279.net8}
N 32580 1180 32680 1180 {lab=279.net8}
N 32680 1180 32680 60 {lab=279.net8}
N 32680 60 32800 60 {lab=279.net8}
N 61680 1190 61680 1180 {lab=278.net8}
N 61680 1180 61880 1180 {lab=278.net8}
N 61680 1180 61680 250 {lab=278.net8}
N 61880 1180 61880 1190 {lab=278.net8}
N 61680 250 61680 240 {lab=278.net8}
N 61680 250 61730 250 {lab=278.net8}
N 61730 250 61730 -80 {lab=278.net8}
N 61730 250 61880 250 {lab=278.net8}
N 61880 250 61880 240 {lab=278.net8}
N 61730 -80 31510 -80 {lab=278.net8}
N 31510 -80 31510 60 {lab=278.net8}
N 31510 -80 31310 -80 {lab=278.net8}
N 31310 -80 31310 1220 {lab=278.net8}
N 31310 1220 31320 1220 {lab=278.net8}
N 31510 60 31520 60 {lab=278.net8}
N 16680 1040 16680 110 {lab=_039_}
N 16680 110 16880 110 {lab=_039_}
N 16680 110 16680 90 {lab=_039_}
N 16880 110 16880 100 {lab=_039_}
N 16880 100 16880 90 {lab=_039_}
N 16880 100 17080 100 {lab=_039_}
N 17080 100 17080 90 {lab=_039_}
N 17080 90 17120 90 {lab=_039_}
N 17120 90 17120 -20 {lab=_039_}
N 17120 -20 45050 -20 {lab=_039_}
N 45050 -20 45050 110 {lab=_039_}
N 45050 110 46520 110 {lab=_039_}
N 46520 110 46520 1370 {lab=_039_}
N 46520 110 46720 110 {lab=_039_}
N 46520 1370 47000 1370 {lab=_039_}
N 46720 110 46720 60 {lab=_039_}
N 46720 60 47000 60 {lab=_039_}
N 60360 1190 60360 1180 {lab=258.net8}
N 60360 1180 60410 1180 {lab=258.net8}
N 60360 1180 60360 270 {lab=258.net8}
N 60410 1180 60410 1670 {lab=258.net8}
N 60410 1180 60560 1180 {lab=258.net8}
N 60560 1180 60560 1190 {lab=258.net8}
N 60360 270 60560 270 {lab=258.net8}
N 60360 270 60360 240 {lab=258.net8}
N 60560 270 60560 240 {lab=258.net8}
N 60410 1670 30380 1670 {lab=258.net8}
N 30380 1670 30380 1220 {lab=258.net8}
N 30380 1220 30390 1220 {lab=258.net8}
N 30390 1220 30400 1220 {lab=258.net8}
N 30390 1220 30390 1180 {lab=258.net8}
N 30390 1180 30480 1180 {lab=258.net8}
N 30480 1180 30480 60 {lab=258.net8}
N 30480 60 30600 60 {lab=258.net8}
N 64320 1190 64320 1180 {lab=280.net8}
N 64320 1180 64370 1180 {lab=280.net8}
N 64320 1180 64320 270 {lab=280.net8}
N 64370 1180 64520 1180 {lab=280.net8}
N 64370 1180 64370 1680 {lab=280.net8}
N 64520 1180 64520 1190 {lab=280.net8}
N 64320 270 64520 270 {lab=280.net8}
N 64320 270 64320 240 {lab=280.net8}
N 64520 270 64520 240 {lab=280.net8}
N 64370 1680 34420 1680 {lab=280.net8}
N 34420 1680 34420 1220 {lab=280.net8}
N 34420 1220 34420 1180 {lab=280.net8}
N 34420 1220 34440 1220 {lab=280.net8}
N 34420 1180 34520 1180 {lab=280.net8}
N 34520 1180 34520 60 {lab=280.net8}
N 34520 60 34640 60 {lab=280.net8}
N 15920 1040 15920 120 {lab=_037_}
N 15920 120 16120 120 {lab=_037_}
N 15920 120 15920 90 {lab=_037_}
N 16120 120 16320 120 {lab=_037_}
N 16120 120 16120 90 {lab=_037_}
N 16320 120 16320 90 {lab=_037_}
N 16320 90 16360 90 {lab=_037_}
N 16360 90 16360 -10 {lab=_037_}
N 16360 -10 42600 -10 {lab=_037_}
N 42600 -10 42600 120 {lab=_037_}
N 42600 120 45400 120 {lab=_037_}
N 45400 120 45600 120 {lab=_037_}
N 45400 120 45400 1370 {lab=_037_}
N 45400 1370 45880 1370 {lab=_037_}
N 45600 120 45600 60 {lab=_037_}
N 45600 60 45880 60 {lab=_037_}
N 59040 1190 59040 1180 {lab=257.net8}
N 59040 1180 59240 1180 {lab=257.net8}
N 59040 1180 59040 250 {lab=257.net8}
N 59240 1180 59240 1190 {lab=257.net8}
N 59040 250 59090 250 {lab=257.net8}
N 59040 250 59040 240 {lab=257.net8}
N 59090 250 59240 250 {lab=257.net8}
N 59090 250 59090 -90 {lab=257.net8}
N 59240 250 59240 240 {lab=257.net8}
N 59090 -90 29670 -90 {lab=257.net8}
N 29670 -90 29670 60 {lab=257.net8}
N 29670 -90 29460 -90 {lab=257.net8}
N 29460 -90 29460 1220 {lab=257.net8}
N 29460 1220 29480 1220 {lab=257.net8}
N 29670 60 29680 60 {lab=257.net8}
N 57720 1190 57720 1180 {lab=256.net8}
N 57720 1180 57920 1180 {lab=256.net8}
N 57720 1180 57720 250 {lab=256.net8}
N 57920 1180 57920 1190 {lab=256.net8}
N 57720 250 57770 250 {lab=256.net8}
N 57720 250 57720 240 {lab=256.net8}
N 57770 250 57770 -100 {lab=256.net8}
N 57770 250 57920 250 {lab=256.net8}
N 57920 250 57920 240 {lab=256.net8}
N 57770 -100 28180 -100 {lab=256.net8}
N 28180 -100 28180 110 {lab=256.net8}
N 28180 110 28280 110 {lab=256.net8}
N 28180 110 28180 1220 {lab=256.net8}
N 28180 1220 28200 1220 {lab=256.net8}
N 28280 110 28280 60 {lab=256.net8}
N 28280 60 28400 60 {lab=256.net8}
N 8960 1340 9010 1340 {lab=255.cki}
N 8960 1340 8960 90 {lab=255.cki}
N 9010 1340 9010 1450 {lab=255.cki}
N 9010 1450 25690 1450 {lab=255.cki}
N 25690 1450 25690 1270 {lab=255.cki}
N 25690 1270 25690 1070 {lab=255.cki}
N 25690 1270 26440 1270 {lab=255.cki}
N 25690 1070 25800 1070 {lab=255.cki}
N 25690 1070 25580 1070 {lab=255.cki}
N 25580 1070 25580 210 {lab=255.cki}
N 25580 210 25600 210 {lab=255.cki}
N 26440 1270 26440 1220 {lab=255.cki}
N 26440 1220 26900 1220 {lab=255.cki}
N 26900 1220 26900 1170 {lab=255.cki}
N 26900 1220 26920 1220 {lab=255.cki}
N 26900 1170 27000 1170 {lab=255.cki}
N 27000 1170 27000 210 {lab=255.cki}
N 27000 210 27120 210 {lab=255.cki}
N 40680 1190 40680 1160 {lab=_011_}
N 40680 1190 41300 1190 {lab=_011_}
N 40680 1160 40480 1160 {lab=_011_}
N 40680 1160 40680 260 {lab=_011_}
N 40480 1160 40480 1190 {lab=_011_}
N 40680 260 40480 260 {lab=_011_}
N 40680 260 40680 240 {lab=_011_}
N 40480 260 40480 240 {lab=_011_}
N 41300 1190 41300 1490 {lab=_011_}
N 41300 1490 56650 1490 {lab=_011_}
N 56650 1490 56650 1370 {lab=_011_}
N 56650 1370 56900 1370 {lab=_011_}
N 56900 1370 56920 1370 {lab=_011_}
N 56900 1370 56900 60 {lab=_011_}
N 56900 60 56920 60 {lab=_011_}
N 8600 1340 8600 1110 {lab=254.cki}
N 8600 1110 8600 90 {lab=254.cki}
N 8600 1110 19920 1110 {lab=254.cki}
N 19920 1110 19920 1070 {lab=254.cki}
N 19920 1070 23350 1070 {lab=254.cki}
N 23350 1070 23550 1070 {lab=254.cki}
N 23350 1070 23350 210 {lab=254.cki}
N 23550 1070 23550 1110 {lab=254.cki}
N 23550 1070 23560 1070 {lab=254.cki}
N 23350 210 23360 210 {lab=254.cki}
N 23550 1110 24200 1110 {lab=254.cki}
N 24200 1110 24200 1220 {lab=254.cki}
N 24200 1220 24660 1220 {lab=254.cki}
N 24660 1220 24680 1220 {lab=254.cki}
N 24660 1220 24660 1160 {lab=254.cki}
N 24660 1160 24760 1160 {lab=254.cki}
N 24760 1160 24760 210 {lab=254.cki}
N 24760 210 24880 210 {lab=254.cki}
N 8240 1340 8240 1070 {lab=253.cki}
N 8240 1070 12150 1070 {lab=253.cki}
N 8240 1070 8240 90 {lab=253.cki}
N 12150 1070 12150 210 {lab=253.cki}
N 12150 1070 12350 1070 {lab=253.cki}
N 12350 1070 12360 1070 {lab=253.cki}
N 12350 1070 12350 1120 {lab=253.cki}
N 12150 210 12160 210 {lab=253.cki}
N 12350 1120 21960 1120 {lab=253.cki}
N 21960 1120 21960 1220 {lab=253.cki}
N 21960 1220 22420 1220 {lab=253.cki}
N 22420 1220 22420 1180 {lab=253.cki}
N 22420 1220 22440 1220 {lab=253.cki}
N 22420 1180 22530 1180 {lab=253.cki}
N 22530 1180 22530 210 {lab=253.cki}
N 22530 210 22640 210 {lab=253.cki}
N 7880 1340 7880 1130 {lab=252.cki}
N 7880 1130 17680 1130 {lab=252.cki}
N 7880 1130 7880 90 {lab=252.cki}
N 17680 1130 17680 1070 {lab=252.cki}
N 17680 1070 19630 1070 {lab=252.cki}
N 19630 1070 19830 1070 {lab=252.cki}
N 19630 1070 19630 210 {lab=252.cki}
N 19830 1070 19830 1130 {lab=252.cki}
N 19830 1070 19840 1070 {lab=252.cki}
N 19630 210 19640 210 {lab=252.cki}
N 19830 1130 20480 1130 {lab=252.cki}
N 20480 1130 20480 1220 {lab=252.cki}
N 20480 1220 20940 1220 {lab=252.cki}
N 20940 1220 20960 1220 {lab=252.cki}
N 20940 1220 20940 1150 {lab=252.cki}
N 20940 1150 21040 1150 {lab=252.cki}
N 21040 1150 21040 210 {lab=252.cki}
N 21040 210 21160 210 {lab=252.cki}
N 7520 1340 7520 1030 {lab=251.cki}
N 7520 1030 7520 90 {lab=251.cki}
N 7520 1030 16720 1030 {lab=251.cki}
N 16720 1030 16720 1070 {lab=251.cki}
N 16720 1070 17390 1070 {lab=251.cki}
N 17390 1070 17390 210 {lab=251.cki}
N 17390 1070 17590 1070 {lab=251.cki}
N 17590 1070 17600 1070 {lab=251.cki}
N 17590 1070 17590 1140 {lab=251.cki}
N 17390 210 17400 210 {lab=251.cki}
N 17590 1140 18240 1140 {lab=251.cki}
N 18240 1140 18240 1220 {lab=251.cki}
N 18240 1220 18700 1220 {lab=251.cki}
N 18700 1220 18700 1150 {lab=251.cki}
N 18700 1220 18720 1220 {lab=251.cki}
N 18700 1150 18800 1150 {lab=251.cki}
N 18800 1150 18800 210 {lab=251.cki}
N 18800 210 18920 210 {lab=251.cki}
N 12200 1190 12200 1020 {lab=253.net1}
N 12200 1190 12240 1190 {lab=253.net1}
N 12200 1020 12200 250 {lab=253.net1}
N 12200 1020 12400 1020 {lab=253.net1}
N 12400 1020 12400 1040 {lab=253.net1}
N 12200 250 12600 250 {lab=253.net1}
N 12200 250 12200 240 {lab=253.net1}
N 12600 250 12600 240 {lab=253.net1}
N 12240 1190 12240 1460 {lab=253.net1}
N 12240 1460 21960 1460 {lab=253.net1}
N 21960 1460 21960 1370 {lab=253.net1}
N 21960 1370 22410 1370 {lab=253.net1}
N 22410 1370 22440 1370 {lab=253.net1}
N 22410 1370 22410 60 {lab=253.net1}
N 22410 60 22440 60 {lab=253.net1}
N 12360 1220 12350 1220 {lab=253.net2}
N 12350 1220 12350 1290 {lab=253.net2}
N 12350 1220 12340 1220 {lab=253.net2}
N 12340 1220 12340 60 {lab=253.net2}
N 12340 60 12360 60 {lab=253.net2}
N 12350 1290 22480 1290 {lab=253.net2}
N 22480 1290 22480 1340 {lab=253.net2}
N 22480 1290 22480 1250 {lab=253.net2}
N 22480 1250 22540 1250 {lab=253.net2}
N 22540 1250 22540 180 {lab=253.net2}
N 22540 180 22480 180 {lab=253.net2}
N 22480 180 22480 90 {lab=253.net2}
N 51720 1190 51720 1160 {lab=_004_}
N 51720 1160 51720 240 {lab=_004_}
N 51720 1160 51920 1160 {lab=_004_}
N 51920 1160 51920 1190 {lab=_004_}
N 51920 1190 51970 1190 {lab=_004_}
N 51720 240 51920 240 {lab=_004_}
N 51920 240 51920 90 {lab=_004_}
N 51970 1190 51970 1460 {lab=_004_}
N 51970 1460 60610 1460 {lab=_004_}
N 60610 1460 60610 1370 {lab=_004_}
N 60610 1370 60860 1370 {lab=_004_}
N 60860 1370 60880 1370 {lab=_004_}
N 60860 1370 60860 60 {lab=_004_}
N 60860 60 60880 60 {lab=_004_}
N 12920 1220 12910 1220 {lab=reset_release_1}
N 12910 1220 12910 1260 {lab=reset_release_1}
N 12910 1220 12910 110 {lab=reset_release_1}
N 12910 1260 13000 1260 {lab=reset_release_1}
N 13000 1260 13000 1220 {lab=reset_release_1}
N 13000 1220 13830 1220 {lab=reset_release_1}
N 13830 1220 13830 1300 {lab=reset_release_1}
N 13830 1220 13840 1220 {lab=reset_release_1}
N 12910 110 12910 60 {lab=reset_release_1}
N 12910 110 13920 110 {lab=reset_release_1}
N 12910 60 12920 60 {lab=reset_release_1}
N 13920 110 13920 60 {lab=reset_release_1}
N 13920 60 14040 60 {lab=reset_release_1}
N 13830 1300 21560 1300 {lab=reset_release_1}
N 21560 1300 21560 90 {lab=reset_release_1}
N 21560 1300 21560 1340 {lab=reset_release_1}
N 17440 1190 17440 1030 {lab=251.net1}
N 17440 1190 17480 1190 {lab=251.net1}
N 17440 1030 17440 250 {lab=251.net1}
N 17440 1030 17640 1030 {lab=251.net1}
N 17640 1030 17640 1040 {lab=251.net1}
N 17440 250 17840 250 {lab=251.net1}
N 17440 250 17440 240 {lab=251.net1}
N 17840 250 17840 240 {lab=251.net1}
N 17840 240 18440 240 {lab=251.net1}
N 17480 1190 17480 1310 {lab=251.net1}
N 17480 1310 18240 1310 {lab=251.net1}
N 18240 1310 18240 1370 {lab=251.net1}
N 18240 1370 18720 1370 {lab=251.net1}
N 18440 240 18440 60 {lab=251.net1}
N 18440 60 18720 60 {lab=251.net1}
N 19680 1190 19720 1190 {lab=252.net1}
N 19680 1190 19680 1030 {lab=252.net1}
N 19680 1030 19880 1030 {lab=252.net1}
N 19680 1030 19680 250 {lab=252.net1}
N 19880 1030 19880 1040 {lab=252.net1}
N 19680 250 19680 240 {lab=252.net1}
N 19680 250 20080 250 {lab=252.net1}
N 20080 250 20080 240 {lab=252.net1}
N 20080 240 20680 240 {lab=252.net1}
N 19720 1190 19720 1280 {lab=252.net1}
N 19720 1280 20480 1280 {lab=252.net1}
N 20480 1280 20480 1370 {lab=252.net1}
N 20480 1370 20960 1370 {lab=252.net1}
N 20680 240 20680 60 {lab=252.net1}
N 20680 60 20960 60 {lab=252.net1}
N 23400 1190 23400 1030 {lab=254.net1}
N 23400 1030 23400 250 {lab=254.net1}
N 23400 1030 23600 1030 {lab=254.net1}
N 23600 1030 23600 1040 {lab=254.net1}
N 23600 1040 24210 1040 {lab=254.net1}
N 23400 250 23400 240 {lab=254.net1}
N 23400 250 23800 250 {lab=254.net1}
N 23800 250 23800 240 {lab=254.net1}
N 23800 240 24400 240 {lab=254.net1}
N 24210 1040 24210 1370 {lab=254.net1}
N 24210 1370 24680 1370 {lab=254.net1}
N 24400 240 24400 60 {lab=254.net1}
N 24400 60 24680 60 {lab=254.net1}
N 25640 1190 25640 1030 {lab=255.net1}
N 25640 1030 25840 1030 {lab=255.net1}
N 25640 1030 25640 250 {lab=255.net1}
N 25840 1030 25840 1040 {lab=255.net1}
N 25840 1040 26450 1040 {lab=255.net1}
N 25640 250 26040 250 {lab=255.net1}
N 25640 250 25640 240 {lab=255.net1}
N 26040 250 26040 240 {lab=255.net1}
N 26040 240 26640 240 {lab=255.net1}
N 26450 1040 26450 1370 {lab=255.net1}
N 26450 1370 26920 1370 {lab=255.net1}
N 26640 240 26640 60 {lab=255.net1}
N 26640 60 26920 60 {lab=255.net1}
N 17600 1220 17580 1220 {lab=251.net2}
N 17580 1220 17580 1150 {lab=251.net2}
N 17580 1150 18250 1150 {lab=251.net2}
N 17580 1150 17580 60 {lab=251.net2}
N 17580 60 17600 60 {lab=251.net2}
N 18250 1150 18250 1140 {lab=251.net2}
N 18250 1140 18810 1140 {lab=251.net2}
N 18810 1140 18810 1250 {lab=251.net2}
N 18810 1140 18810 180 {lab=251.net2}
N 18810 1250 18760 1250 {lab=251.net2}
N 18760 1250 18760 1340 {lab=251.net2}
N 18810 180 18760 180 {lab=251.net2}
N 18760 180 18760 90 {lab=251.net2}
N 19840 1220 19820 1220 {lab=252.net2}
N 19820 1220 19820 1140 {lab=252.net2}
N 19820 1140 21050 1140 {lab=252.net2}
N 19820 1140 19820 60 {lab=252.net2}
N 19820 60 19840 60 {lab=252.net2}
N 21050 1140 21050 180 {lab=252.net2}
N 21050 1140 21050 1250 {lab=252.net2}
N 21050 1250 21000 1250 {lab=252.net2}
N 21000 1250 21000 1340 {lab=252.net2}
N 21050 180 21000 180 {lab=252.net2}
N 21000 180 21000 90 {lab=252.net2}
N 23560 1220 23550 1220 {lab=254.net2}
N 23550 1220 23550 1270 {lab=254.net2}
N 23550 1220 23540 1220 {lab=254.net2}
N 23540 1220 23540 170 {lab=254.net2}
N 23540 170 24720 170 {lab=254.net2}
N 23540 170 23540 60 {lab=254.net2}
N 23540 60 23560 60 {lab=254.net2}
N 23550 1270 24720 1270 {lab=254.net2}
N 24720 1270 24720 1340 {lab=254.net2}
N 24720 1270 24720 1250 {lab=254.net2}
N 24720 170 24720 90 {lab=254.net2}
N 24720 170 24720 180 {lab=254.net2}
N 25800 1220 25790 1220 {lab=255.net2}
N 25790 1220 25790 170 {lab=255.net2}
N 25790 1220 25790 1280 {lab=255.net2}
N 25790 170 26960 170 {lab=255.net2}
N 25790 170 25790 60 {lab=255.net2}
N 25790 60 25800 60 {lab=255.net2}
N 25790 1280 26960 1280 {lab=255.net2}
N 26960 1280 26960 1250 {lab=255.net2}
N 26960 1280 26960 1340 {lab=255.net2}
N 26960 170 26960 180 {lab=255.net2}
N 26960 170 26960 90 {lab=255.net2}
N 52280 1190 52280 1160 {lab=_084_}
N 52280 1160 52280 240 {lab=_084_}
N 52280 1160 52480 1160 {lab=_084_}
N 52480 1160 52480 1190 {lab=_084_}
N 52480 1190 52530 1190 {lab=_084_}
N 52530 1190 52530 1370 {lab=_084_}
N 52530 1370 52800 1370 {lab=_084_}
N 52280 240 52480 240 {lab=_084_}
N 52480 240 52480 100 {lab=_084_}
N 52480 100 53080 100 {lab=_084_}
N 52480 100 52480 90 {lab=_084_}
N 53080 100 53080 60 {lab=_084_}
N 53080 60 53200 60 {lab=_084_}
N 18760 1190 18820 1190 {lab=251.net8}
N 18760 1190 18760 1130 {lab=251.net8}
N 18820 1190 18820 1180 {lab=251.net8}
N 18820 1180 18960 1180 {lab=251.net8}
N 18960 1180 18960 1190 {lab=251.net8}
N 18760 1130 18150 1130 {lab=251.net8}
N 18760 1130 18760 250 {lab=251.net8}
N 18150 1130 18150 1220 {lab=251.net8}
N 18150 1220 18160 1220 {lab=251.net8}
N 18760 250 18760 240 {lab=251.net8}
N 18760 250 18960 250 {lab=251.net8}
N 18760 250 18350 250 {lab=251.net8}
N 18960 250 18960 240 {lab=251.net8}
N 18350 250 18350 60 {lab=251.net8}
N 18350 60 18360 60 {lab=251.net8}
N 21000 1190 21000 1130 {lab=252.net8}
N 21000 1190 21060 1190 {lab=252.net8}
N 21060 1190 21060 1180 {lab=252.net8}
N 21060 1180 21200 1180 {lab=252.net8}
N 21200 1180 21200 1190 {lab=252.net8}
N 21000 1130 20930 1130 {lab=252.net8}
N 21000 1130 21000 250 {lab=252.net8}
N 20930 1130 20930 1150 {lab=252.net8}
N 20930 1150 20390 1150 {lab=252.net8}
N 20390 1150 20390 1220 {lab=252.net8}
N 20390 1220 20400 1220 {lab=252.net8}
N 21000 250 21200 250 {lab=252.net8}
N 21000 250 20590 250 {lab=252.net8}
N 21000 250 21000 240 {lab=252.net8}
N 21200 250 21200 240 {lab=252.net8}
N 20590 250 20590 60 {lab=252.net8}
N 20590 60 20600 60 {lab=252.net8}
N 22480 1190 22480 1150 {lab=253.net8}
N 22480 1190 22550 1190 {lab=253.net8}
N 22550 1190 22550 1180 {lab=253.net8}
N 22550 1180 22680 1180 {lab=253.net8}
N 22680 1180 22680 1190 {lab=253.net8}
N 22480 1150 21860 1150 {lab=253.net8}
N 22480 1150 22480 250 {lab=253.net8}
N 21860 1150 21860 1220 {lab=253.net8}
N 21860 1220 21880 1220 {lab=253.net8}
N 22480 250 22070 250 {lab=253.net8}
N 22480 250 22480 240 {lab=253.net8}
N 22480 250 22680 250 {lab=253.net8}
N 22680 250 22680 240 {lab=253.net8}
N 22070 250 22070 60 {lab=253.net8}
N 22070 60 22080 60 {lab=253.net8}
N 24720 1190 24770 1190 {lab=254.net8}
N 24770 1190 24770 1180 {lab=254.net8}
N 24770 1180 24770 1150 {lab=254.net8}
N 24770 1180 24920 1180 {lab=254.net8}
N 24920 1180 24920 1190 {lab=254.net8}
N 24770 1150 24720 1150 {lab=254.net8}
N 24720 1150 24110 1150 {lab=254.net8}
N 24720 1150 24720 250 {lab=254.net8}
N 24110 1150 24110 1220 {lab=254.net8}
N 24110 1220 24120 1220 {lab=254.net8}
N 24720 250 24920 250 {lab=254.net8}
N 24720 250 24310 250 {lab=254.net8}
N 24720 250 24720 240 {lab=254.net8}
N 24920 250 24920 240 {lab=254.net8}
N 24310 250 24310 60 {lab=254.net8}
N 24310 60 24320 60 {lab=254.net8}
N 26960 1190 27010 1190 {lab=255.net8}
N 27010 1190 27010 1180 {lab=255.net8}
N 27010 1180 27160 1180 {lab=255.net8}
N 27010 1180 27010 1160 {lab=255.net8}
N 27160 1180 27160 1190 {lab=255.net8}
N 27010 1160 26960 1160 {lab=255.net8}
N 26960 1160 26350 1160 {lab=255.net8}
N 26960 1160 26960 250 {lab=255.net8}
N 26350 1160 26350 1220 {lab=255.net8}
N 26350 1220 26360 1220 {lab=255.net8}
N 26960 250 26550 250 {lab=255.net8}
N 26960 250 26960 240 {lab=255.net8}
N 26960 250 27160 250 {lab=255.net8}
N 27160 250 27160 240 {lab=255.net8}
N 26550 250 26550 60 {lab=255.net8}
N 26550 60 26560 60 {lab=255.net8}
N 39920 1190 39920 260 {lab=_116_}
N 39920 1190 40120 1190 {lab=_116_}
N 40120 1190 40120 1300 {lab=_116_}
N 40120 1300 40530 1300 {lab=_116_}
N 40120 1300 40120 1340 {lab=_116_}
N 40530 1300 40530 1370 {lab=_116_}
N 40530 1370 40640 1370 {lab=_116_}
N 39920 260 40120 260 {lab=_116_}
N 39920 260 39920 240 {lab=_116_}
N 40120 260 40120 240 {lab=_116_}
N 40120 240 40160 240 {lab=_116_}
N 40160 240 40160 210 {lab=_116_}
N 40160 210 40440 210 {lab=_116_}
N 50240 1190 50240 1140 {lab=_082_}
N 50240 1140 50440 1140 {lab=_082_}
N 50240 1140 50240 240 {lab=_082_}
N 50440 1140 50440 1190 {lab=_082_}
N 50440 1190 50490 1190 {lab=_082_}
N 50490 1190 50490 1370 {lab=_082_}
N 50490 1370 50760 1370 {lab=_082_}
N 50240 240 50440 240 {lab=_082_}
N 50440 240 50440 110 {lab=_082_}
N 50440 110 50840 110 {lab=_082_}
N 50440 110 50440 90 {lab=_082_}
N 50840 110 50840 60 {lab=_082_}
N 50840 60 50960 60 {lab=_082_}
N 52840 1040 52900 1040 {lab=236.Z_neg}
N 52840 1040 52840 110 {lab=236.Z_neg}
N 52840 110 52840 90 {lab=236.Z_neg}
N 52840 110 53040 110 {lab=236.Z_neg}
N 52900 1040 52900 1370 {lab=236.Z_neg}
N 52900 1370 53560 1370 {lab=236.Z_neg}
N 53040 110 53040 90 {lab=236.Z_neg}
N 53040 110 53240 110 {lab=236.Z_neg}
N 53240 110 53240 90 {lab=236.Z_neg}
N 53240 90 53280 90 {lab=236.Z_neg}
N 53280 90 53280 60 {lab=236.Z_neg}
N 53280 60 53560 60 {lab=236.Z_neg}
N 56960 1190 56960 1180 {lab=256.net1}
N 56960 1180 57210 1180 {lab=256.net1}
N 56960 1180 56960 1030 {lab=256.net1}
N 56960 1030 56960 260 {lab=256.net1}
N 56960 1030 57160 1030 {lab=256.net1}
N 57160 1030 57160 1040 {lab=256.net1}
N 57210 1180 57210 1370 {lab=256.net1}
N 57210 1370 57680 1370 {lab=256.net1}
N 56960 260 57360 260 {lab=256.net1}
N 56960 260 56960 240 {lab=256.net1}
N 57360 260 57360 240 {lab=256.net1}
N 57360 260 57410 260 {lab=256.net1}
N 57410 260 57410 60 {lab=256.net1}
N 57410 60 57680 60 {lab=256.net1}
N 58280 1190 58280 1180 {lab=257.net1}
N 58280 1180 58280 1030 {lab=257.net1}
N 58280 1180 58530 1180 {lab=257.net1}
N 58280 1030 58480 1030 {lab=257.net1}
N 58280 1030 58280 260 {lab=257.net1}
N 58480 1030 58480 1040 {lab=257.net1}
N 58530 1180 58530 1370 {lab=257.net1}
N 58530 1370 59000 1370 {lab=257.net1}
N 58280 260 58680 260 {lab=257.net1}
N 58280 260 58280 240 {lab=257.net1}
N 58680 260 58730 260 {lab=257.net1}
N 58680 260 58680 240 {lab=257.net1}
N 58730 260 58730 60 {lab=257.net1}
N 58730 60 59000 60 {lab=257.net1}
N 59600 1190 59600 1180 {lab=258.net1}
N 59600 1180 59600 1030 {lab=258.net1}
N 59600 1180 59850 1180 {lab=258.net1}
N 59600 1030 59800 1030 {lab=258.net1}
N 59600 1030 59600 270 {lab=258.net1}
N 59800 1030 59800 1040 {lab=258.net1}
N 59850 1180 59850 1370 {lab=258.net1}
N 59850 1370 60320 1370 {lab=258.net1}
N 59600 270 60000 270 {lab=258.net1}
N 59600 270 59600 240 {lab=258.net1}
N 60000 270 60000 240 {lab=258.net1}
N 60000 240 60050 240 {lab=258.net1}
N 60050 240 60050 60 {lab=258.net1}
N 60050 60 60320 60 {lab=258.net1}
N 60920 1190 60920 1180 {lab=278.net1}
N 60920 1180 61170 1180 {lab=278.net1}
N 60920 1180 60920 1030 {lab=278.net1}
N 60920 1030 61120 1030 {lab=278.net1}
N 60920 1030 60920 260 {lab=278.net1}
N 61120 1030 61120 1040 {lab=278.net1}
N 61170 1180 61170 1370 {lab=278.net1}
N 61170 1370 61640 1370 {lab=278.net1}
N 60920 260 60920 240 {lab=278.net1}
N 60920 260 61320 260 {lab=278.net1}
N 61320 260 61370 260 {lab=278.net1}
N 61320 260 61320 240 {lab=278.net1}
N 61370 260 61370 60 {lab=278.net1}
N 61370 60 61640 60 {lab=278.net1}
N 62240 1190 62240 1180 {lab=279.net1}
N 62240 1180 62240 1030 {lab=279.net1}
N 62240 1180 62490 1180 {lab=279.net1}
N 62240 1030 62440 1030 {lab=279.net1}
N 62240 1030 62240 270 {lab=279.net1}
N 62440 1030 62440 1040 {lab=279.net1}
N 62490 1180 62490 1370 {lab=279.net1}
N 62490 1370 62960 1370 {lab=279.net1}
N 62240 270 62640 270 {lab=279.net1}
N 62240 270 62240 240 {lab=279.net1}
N 62640 270 62640 240 {lab=279.net1}
N 62640 240 62690 240 {lab=279.net1}
N 62690 240 62690 60 {lab=279.net1}
N 62690 60 62960 60 {lab=279.net1}
N 63560 1190 63560 1180 {lab=280.net1}
N 63560 1180 63810 1180 {lab=280.net1}
N 63560 1180 63560 1030 {lab=280.net1}
N 63560 1030 63560 270 {lab=280.net1}
N 63560 1030 63760 1030 {lab=280.net1}
N 63760 1030 63760 1040 {lab=280.net1}
N 63810 1180 63810 1370 {lab=280.net1}
N 63810 1370 64280 1370 {lab=280.net1}
N 63560 270 63960 270 {lab=280.net1}
N 63560 270 63560 240 {lab=280.net1}
N 63960 270 63960 240 {lab=280.net1}
N 63960 240 64010 240 {lab=280.net1}
N 64010 240 64010 60 {lab=280.net1}
N 64010 60 64280 60 {lab=280.net1}
N 57120 1220 57110 1220 {lab=256.net2}
N 57110 1220 57110 1270 {lab=256.net2}
N 57110 1220 57100 1220 {lab=256.net2}
N 57110 1270 57720 1270 {lab=256.net2}
N 57720 1270 57720 1250 {lab=256.net2}
N 57720 1270 57720 1340 {lab=256.net2}
N 57100 1220 57100 160 {lab=256.net2}
N 57100 160 57720 160 {lab=256.net2}
N 57100 160 57100 60 {lab=256.net2}
N 57100 60 57120 60 {lab=256.net2}
N 57720 160 57720 180 {lab=256.net2}
N 57720 160 57720 90 {lab=256.net2}
N 58440 1220 58430 1220 {lab=257.net2}
N 58430 1220 58420 1220 {lab=257.net2}
N 58430 1220 58430 1270 {lab=257.net2}
N 58430 1270 59040 1270 {lab=257.net2}
N 59040 1270 59040 1340 {lab=257.net2}
N 59040 1270 59040 1250 {lab=257.net2}
N 58420 1220 58420 160 {lab=257.net2}
N 58420 160 59040 160 {lab=257.net2}
N 58420 160 58420 60 {lab=257.net2}
N 58420 60 58440 60 {lab=257.net2}
N 59040 160 59040 90 {lab=257.net2}
N 59040 160 59040 180 {lab=257.net2}
N 59760 1220 59750 1220 {lab=258.net2}
N 59750 1220 59740 1220 {lab=258.net2}
N 59750 1220 59750 1270 {lab=258.net2}
N 59750 1270 60360 1270 {lab=258.net2}
N 60360 1270 60360 1250 {lab=258.net2}
N 60360 1270 60360 1340 {lab=258.net2}
N 59740 1220 59740 170 {lab=258.net2}
N 59740 170 59740 60 {lab=258.net2}
N 59740 170 60360 170 {lab=258.net2}
N 59740 60 59760 60 {lab=258.net2}
N 60360 170 60360 180 {lab=258.net2}
N 60360 170 60360 90 {lab=258.net2}
N 61080 1220 61070 1220 {lab=278.net2}
N 61070 1220 61070 1270 {lab=278.net2}
N 61070 1220 61060 1220 {lab=278.net2}
N 61070 1270 61680 1270 {lab=278.net2}
N 61680 1270 61680 1250 {lab=278.net2}
N 61680 1270 61680 1340 {lab=278.net2}
N 61060 1220 61060 160 {lab=278.net2}
N 61060 160 61680 160 {lab=278.net2}
N 61060 160 61060 60 {lab=278.net2}
N 61060 60 61080 60 {lab=278.net2}
N 61680 160 61680 90 {lab=278.net2}
N 61680 160 61680 180 {lab=278.net2}
N 62400 1220 62390 1220 {lab=279.net2}
N 62390 1220 62380 1220 {lab=279.net2}
N 62390 1220 62390 1270 {lab=279.net2}
N 62390 1270 63000 1270 {lab=279.net2}
N 63000 1270 63000 1340 {lab=279.net2}
N 63000 1270 63000 1250 {lab=279.net2}
N 62380 1220 62380 170 {lab=279.net2}
N 62380 170 63000 170 {lab=279.net2}
N 62380 170 62380 60 {lab=279.net2}
N 62380 60 62400 60 {lab=279.net2}
N 63000 170 63000 90 {lab=279.net2}
N 63000 170 63000 180 {lab=279.net2}
N 63720 1220 63710 1220 {lab=280.net2}
N 63710 1220 63710 1270 {lab=280.net2}
N 63710 1220 63700 1220 {lab=280.net2}
N 63710 1270 64320 1270 {lab=280.net2}
N 64320 1270 64320 1250 {lab=280.net2}
N 64320 1270 64320 1340 {lab=280.net2}
N 63700 1220 63700 170 {lab=280.net2}
N 63700 170 64320 170 {lab=280.net2}
N 63700 170 63700 60 {lab=280.net2}
N 63700 60 63720 60 {lab=280.net2}
N 64320 170 64320 90 {lab=280.net2}
N 64320 170 64320 180 {lab=280.net2}
N 55840 1190 56040 1190 {lab=_088_}
N 55840 1190 55840 250 {lab=_088_}
N 56040 1190 56040 1340 {lab=_088_}
N 56040 1340 56080 1340 {lab=_088_}
N 56080 1340 56080 1370 {lab=_088_}
N 56080 1370 56360 1370 {lab=_088_}
N 55840 250 55840 240 {lab=_088_}
N 55840 250 56040 250 {lab=_088_}
N 56040 250 56040 240 {lab=_088_}
N 56040 240 56090 240 {lab=_088_}
N 56090 240 56090 60 {lab=_088_}
N 56090 60 56360 60 {lab=_088_}
N 1680 1340 1680 1320 {lab=_096_}
N 1680 1320 1680 360 {lab=_096_}
N 1680 1320 2280 1320 {lab=_096_}
N 2280 1320 2280 1370 {lab=_096_}
N 2280 1370 2390 1370 {lab=_096_}
N 2390 1370 2390 1690 {lab=_096_}
N 2390 1370 2400 1370 {lab=_096_}
N 1680 360 1680 90 {lab=_096_}
N 1680 360 2000 360 {lab=_096_}
N 2390 1690 64920 1690 {lab=_096_}
N 64920 1690 64920 510 {lab=_096_}
N 64920 510 64900 510 {lab=_096_}
N 15000 1340 15000 90 {lab=_120_}
N 15000 1340 15040 1340 {lab=_120_}
N 15040 1340 15040 1700 {lab=_120_}
N 15040 1700 43160 1700 {lab=_120_}
N 43160 1700 64560 1700 {lab=_120_}
N 43160 1700 43160 1370 {lab=_120_}
N 43160 1370 43430 1370 {lab=_120_}
N 43430 1370 43440 1370 {lab=_120_}
N 43430 1370 43430 60 {lab=_120_}
N 43430 60 43440 60 {lab=_120_}
N 64560 1700 64560 870 {lab=_120_}
N 64560 870 64900 870 {lab=_120_}
N 3000 1340 3000 1320 {lab=_080_}
N 3000 1320 3200 1320 {lab=_080_}
N 3000 1320 3000 240 {lab=_080_}
N 3200 1320 3200 1340 {lab=_080_}
N 3200 1340 3240 1340 {lab=_080_}
N 3240 1340 3240 1710 {lab=_080_}
N 3240 1710 49160 1710 {lab=_080_}
N 49160 1710 49160 1370 {lab=_080_}
N 49160 1370 49620 1370 {lab=_080_}
N 49620 1370 49640 1370 {lab=_080_}
N 49620 1370 49620 60 {lab=_080_}
N 49620 60 49640 60 {lab=_080_}
N 29120 1370 29110 1370 {lab=capture}
N 29110 1370 29110 1340 {lab=capture}
N 29110 1340 28800 1340 {lab=capture}
N 29110 1340 29110 90 {lab=capture}
N 29110 90 28800 90 {lab=capture}
N 29110 90 29110 60 {lab=capture}
N 29110 60 29110 -110 {lab=capture}
N 29110 60 29120 60 {lab=capture}
N 29110 -110 64950 -110 {lab=capture}
N 64950 -110 64950 990 {lab=capture}
N 64950 990 64900 990 {lab=capture}
N 45320 1220 45310 1220 {lab=cfg_0}
N 45310 1220 45310 1160 {lab=cfg_0}
N 45310 1160 45410 1160 {lab=cfg_0}
N 45410 1160 45410 60 {lab=cfg_0}
N 45410 60 45410 -70 {lab=cfg_0}
N 45410 60 45520 60 {lab=cfg_0}
N 45410 -70 45410 -120 {lab=cfg_0}
N 45410 -70 30370 -70 {lab=cfg_0}
N 30370 -70 30370 90 {lab=cfg_0}
N 30370 90 30370 1340 {lab=cfg_0}
N 30370 90 30080 90 {lab=cfg_0}
N 30370 1340 30080 1340 {lab=cfg_0}
N 45410 -120 64960 -120 {lab=cfg_0}
N 64960 -120 64960 1030 {lab=cfg_0}
N 64960 1030 64900 1030 {lab=cfg_0}
N 46440 1220 46430 1220 {lab=cfg_1}
N 46430 1220 46430 130 {lab=cfg_1}
N 46430 130 46430 100 {lab=cfg_1}
N 46430 130 44740 130 {lab=cfg_1}
N 46430 100 46520 100 {lab=cfg_1}
N 46520 100 46520 60 {lab=cfg_1}
N 46520 60 46630 60 {lab=cfg_1}
N 46630 60 46630 -130 {lab=cfg_1}
N 46630 60 46640 60 {lab=cfg_1}
N 44740 130 44740 -30 {lab=cfg_1}
N 44740 -30 31300 -30 {lab=cfg_1}
N 31300 -30 31300 90 {lab=cfg_1}
N 31300 90 31000 90 {lab=cfg_1}
N 31300 90 31300 1340 {lab=cfg_1}
N 31300 1340 31000 1340 {lab=cfg_1}
N 46630 -130 64970 -130 {lab=cfg_1}
N 64970 -130 64970 1070 {lab=cfg_1}
N 64970 1070 64900 1070 {lab=cfg_1}
N 43120 1340 43170 1340 {lab=_119_}
N 43120 1340 43120 100 {lab=_119_}
N 43170 1340 43170 1480 {lab=_119_}
N 43170 1480 43930 1480 {lab=_119_}
N 43930 1480 43930 1370 {lab=_119_}
N 43930 1480 64380 1480 {lab=_119_}
N 43930 1370 44200 1370 {lab=_119_}
N 43120 100 43520 100 {lab=_119_}
N 43120 100 43120 90 {lab=_119_}
N 43520 100 43520 60 {lab=_119_}
N 43520 60 44200 60 {lab=_119_}
N 64380 1480 64380 830 {lab=_119_}
N 64380 830 64900 830 {lab=_119_}
N 12920 1370 12910 1370 {lab=ena}
N 12910 1370 12910 1430 {lab=ena}
N 12910 1430 13110 1430 {lab=ena}
N 13110 1430 13110 100 {lab=ena}
N 13110 1430 13560 1430 {lab=ena}
N 13560 1430 13560 1370 {lab=ena}
N 13560 1370 13840 1370 {lab=ena}
N 13110 100 13110 60 {lab=ena}
N 13110 100 13560 100 {lab=ena}
N 13110 60 13120 60 {lab=ena}
N 13110 60 13110 -10 {lab=ena}
N 13560 100 13560 60 {lab=ena}
N 13560 60 13840 60 {lab=ena}
N 13110 -10 -70 -10 {lab=ena}
N -70 -10 -70 530 {lab=ena}
N -70 530 -60 530 {lab=ena}
N 47040 1190 47090 1190 {lab=_013_}
N 47040 1190 47040 100 {lab=_013_}
N 47040 100 47040 90 {lab=_013_}
N 47040 100 47240 100 {lab=_013_}
N 47240 100 47240 90 {lab=_013_}
N 47090 1190 47090 1290 {lab=_013_}
N 47090 1290 51980 1290 {lab=_013_}
N 51980 1290 51980 1470 {lab=_013_}
N 51980 1470 59300 1470 {lab=_013_}
N 59300 1470 59300 1370 {lab=_013_}
N 59300 1370 59540 1370 {lab=_013_}
N 59540 1370 59540 60 {lab=_013_}
N 59540 1370 59560 1370 {lab=_013_}
N 59540 60 59560 60 {lab=_013_}
N 45920 1190 45920 1160 {lab=_012_}
N 45920 1160 49170 1160 {lab=_012_}
N 45920 1160 45920 120 {lab=_012_}
N 45920 120 45920 90 {lab=_012_}
N 45920 120 46120 120 {lab=_012_}
N 46120 120 46120 90 {lab=_012_}
N 49170 1160 49170 1260 {lab=_012_}
N 49170 1260 50300 1260 {lab=_012_}
N 50300 1260 50300 1300 {lab=_012_}
N 50300 1300 57970 1300 {lab=_012_}
N 57970 1300 57970 1370 {lab=_012_}
N 57970 1370 58220 1370 {lab=_012_}
N 58220 1370 58240 1370 {lab=_012_}
N 58220 1370 58220 60 {lab=_012_}
N 58220 60 58240 60 {lab=_012_}
N 53960 1340 53960 1320 {lab=_005_}
N 53960 1320 54160 1320 {lab=_005_}
N 53960 1320 53960 240 {lab=_005_}
N 54160 1320 54160 1340 {lab=_005_}
N 54160 1320 55330 1320 {lab=_005_}
N 55330 1320 55330 1430 {lab=_005_}
N 55330 1430 61940 1430 {lab=_005_}
N 61940 1430 61940 1370 {lab=_005_}
N 61940 1370 62180 1370 {lab=_005_}
N 62180 1370 62200 1370 {lab=_005_}
N 62180 1370 62180 60 {lab=_005_}
N 62180 60 62200 60 {lab=_005_}
N 56400 1340 56400 1320 {lab=_006_}
N 56400 1320 56600 1320 {lab=_006_}
N 56400 1320 56400 240 {lab=_006_}
N 56600 1320 56600 1340 {lab=_006_}
N 56600 1340 56660 1340 {lab=_006_}
N 56660 1340 56660 1440 {lab=_006_}
N 56660 1440 63260 1440 {lab=_006_}
N 63260 1440 63260 1370 {lab=_006_}
N 63260 1370 63500 1370 {lab=_006_}
N 63500 1370 63500 60 {lab=_006_}
N 63500 1370 63520 1370 {lab=_006_}
N 63500 60 63520 60 {lab=_006_}
N 1120 1190 1120 100 {lab=_030_}
N 1120 1190 1720 1190 {lab=_030_}
N 1720 1190 1720 1370 {lab=_030_}
N 1720 1370 2000 1370 {lab=_030_}
N 1120 100 1320 100 {lab=_030_}
N 1120 100 1120 90 {lab=_030_}
N 1320 100 1320 90 {lab=_030_}
N 1320 100 1720 100 {lab=_030_}
N 1720 100 1720 60 {lab=_030_}
N 1720 60 2000 60 {lab=_030_}
N 36520 1190 36560 1190 {lab=_110_}
N 36520 1190 36520 100 {lab=_110_}
N 36560 1190 36560 1300 {lab=_110_}
N 36560 1300 37120 1300 {lab=_110_}
N 37120 1300 37120 1370 {lab=_110_}
N 37120 1370 37240 1370 {lab=_110_}
N 36520 100 36720 100 {lab=_110_}
N 36520 100 36520 90 {lab=_110_}
N 36720 100 36720 90 {lab=_110_}
N 36720 90 36760 90 {lab=_110_}
N 36760 90 36760 60 {lab=_110_}
N 36760 60 37040 60 {lab=_110_}
N 45360 1190 45410 1190 {lab=_036_}
N 45360 1190 45360 140 {lab=_036_}
N 45410 1190 45410 1220 {lab=_036_}
N 45410 1220 45880 1220 {lab=_036_}
N 45360 140 45360 90 {lab=_036_}
N 45360 140 45560 140 {lab=_036_}
N 45560 140 45560 90 {lab=_036_}
N 45560 140 45960 140 {lab=_036_}
N 45960 140 45960 60 {lab=_036_}
N 45960 60 46080 60 {lab=_036_}
N 46480 1190 46530 1190 {lab=_038_}
N 46480 1190 46480 120 {lab=_038_}
N 46530 1190 46530 1220 {lab=_038_}
N 46530 1220 47000 1220 {lab=_038_}
N 46480 120 46680 120 {lab=_038_}
N 46480 120 46480 90 {lab=_038_}
N 46680 120 46680 90 {lab=_038_}
N 46680 120 47080 120 {lab=_038_}
N 47080 120 47080 60 {lab=_038_}
N 47080 60 47200 60 {lab=_038_}
N 55280 1190 55280 100 {lab=_087_}
N 55280 1190 55330 1190 {lab=_087_}
N 55330 1190 55330 1260 {lab=_087_}
N 55330 1260 55880 1260 {lab=_087_}
N 55880 1260 55880 1370 {lab=_087_}
N 55880 1370 56000 1370 {lab=_087_}
N 55280 100 55480 100 {lab=_087_}
N 55280 100 55280 90 {lab=_087_}
N 55480 100 55480 90 {lab=_087_}
N 55480 90 55520 90 {lab=_087_}
N 55520 90 55520 60 {lab=_087_}
N 55520 60 55800 60 {lab=_087_}
N 12960 1190 12960 120 {lab=132.Z_neg}
N 12960 1190 13010 1190 {lab=132.Z_neg}
N 13010 1190 13010 1370 {lab=132.Z_neg}
N 13010 1370 13480 1370 {lab=132.Z_neg}
N 12960 120 12960 90 {lab=132.Z_neg}
N 12960 120 13160 120 {lab=132.Z_neg}
N 13160 120 13160 90 {lab=132.Z_neg}
N 13160 90 13200 90 {lab=132.Z_neg}
N 13200 90 13200 60 {lab=132.Z_neg}
N 13200 60 13480 60 {lab=132.Z_neg}
N 42560 1340 42560 240 {lab=152.Z_neg}
N 42560 1340 42610 1340 {lab=152.Z_neg}
N 42610 1340 42610 1450 {lab=152.Z_neg}
N 42610 1450 42800 1450 {lab=152.Z_neg}
N 42800 1450 42800 1370 {lab=152.Z_neg}
N 42800 1370 43080 1370 {lab=152.Z_neg}
N 42800 1370 42800 1340 {lab=152.Z_neg}
N 42800 1340 42760 1340 {lab=152.Z_neg}
N 42560 240 42610 240 {lab=152.Z_neg}
N 42610 240 42610 60 {lab=152.Z_neg}
N 42610 60 43080 60 {lab=152.Z_neg}
N 14440 1190 14490 1190 {lab=153.Z_neg}
N 14440 1190 14440 100 {lab=153.Z_neg}
N 14490 1190 14490 1370 {lab=153.Z_neg}
N 14490 1370 14960 1370 {lab=153.Z_neg}
N 14440 100 14440 90 {lab=153.Z_neg}
N 14440 100 14640 100 {lab=153.Z_neg}
N 14640 100 14640 90 {lab=153.Z_neg}
N 14640 90 14680 90 {lab=153.Z_neg}
N 14680 90 14680 60 {lab=153.Z_neg}
N 14680 60 14960 60 {lab=153.Z_neg}
N 48560 1340 48560 1310 {lab=_078_}
N 48560 1310 48760 1310 {lab=_078_}
N 48560 1310 48560 240 {lab=_078_}
N 48760 1310 48760 1340 {lab=_078_}
N 48760 1340 48800 1340 {lab=_078_}
N 48800 1340 48800 1370 {lab=_078_}
N 48800 1370 49080 1370 {lab=_078_}
N 48560 240 48600 240 {lab=_078_}
N 48600 240 48600 60 {lab=_078_}
N 48600 60 49080 60 {lab=_078_}
N 50800 1190 50840 1190 {lab=233.Z_neg}
N 50800 1190 50800 120 {lab=233.Z_neg}
N 50840 1190 50840 1370 {lab=233.Z_neg}
N 50840 1370 51320 1370 {lab=233.Z_neg}
N 50800 120 51000 120 {lab=233.Z_neg}
N 50800 120 50800 90 {lab=233.Z_neg}
N 51000 120 51000 90 {lab=233.Z_neg}
N 51000 90 51040 90 {lab=233.Z_neg}
N 51040 90 51040 60 {lab=233.Z_neg}
N 51040 60 51320 60 {lab=233.Z_neg}
N 15360 1340 15360 1320 {lab=_124_}
N 15360 1320 15560 1320 {lab=_124_}
N 15360 1320 15360 240 {lab=_124_}
N 15560 1320 15560 1340 {lab=_124_}
N 15560 1340 15600 1340 {lab=_124_}
N 15600 1340 15600 1720 {lab=_124_}
N 15600 1720 64570 1720 {lab=_124_}
N 64570 1720 64570 950 {lab=_124_}
N 64570 950 64900 950 {lab=_124_}
N 29160 1340 29160 1160 {lab=_094_}
N 29160 1160 40160 1160 {lab=_094_}
N 29160 1160 29160 90 {lab=_094_}
N 40160 1160 40170 1160 {lab=_094_}
N 40160 1160 40160 1370 {lab=_094_}
N 40160 1370 40440 1370 {lab=_094_}
N 40170 1160 40170 60 {lab=_094_}
N 40170 60 40440 60 {lab=_094_}
N 27880 1340 27880 1280 {lab=_100_}
N 27880 1280 27880 90 {lab=_100_}
N 27880 1280 36170 1280 {lab=_100_}
N 36170 1280 36170 1320 {lab=_100_}
N 36170 1320 36560 1320 {lab=_100_}
N 36560 1320 36560 1370 {lab=_100_}
N 36560 1370 37020 1370 {lab=_100_}
N 37020 1370 37040 1370 {lab=_100_}
N 37020 1370 37020 210 {lab=_100_}
N 37020 210 37040 210 {lab=_100_}
N 27840 1370 27830 1370 {lab=start_previous}
N 27830 1370 27830 1340 {lab=start_previous}
N 27830 1340 27830 90 {lab=start_previous}
N 27830 1340 27520 1340 {lab=start_previous}
N 27830 90 27830 60 {lab=start_previous}
N 27830 90 27520 90 {lab=start_previous}
N 27830 60 27840 60 {lab=start_previous}
N 51360 1340 51360 1220 {lab=_083_}
N 51360 1220 51360 90 {lab=_083_}
N 51360 1220 51680 1220 {lab=_083_}
N 51360 90 51400 90 {lab=_083_}
N 51400 90 51400 60 {lab=_083_}
N 51400 60 51680 60 {lab=_083_}
N 53600 1340 53640 1340 {lab=_085_}
N 53600 1340 53600 90 {lab=_085_}
N 53640 1340 53640 1370 {lab=_085_}
N 53640 1370 53920 1370 {lab=_085_}
N 53600 90 53640 90 {lab=_085_}
N 53640 90 53640 60 {lab=_085_}
N 53640 60 53920 60 {lab=_085_}
N 19320 1340 19320 90 {lab=reset_release_0}
N 19320 1340 19360 1340 {lab=reset_release_0}
N 19360 1340 19360 1370 {lab=reset_release_0}
N 19360 1370 19640 1370 {lab=reset_release_0}
N 19320 90 19360 90 {lab=reset_release_0}
N 19360 90 19360 60 {lab=reset_release_0}
N 19360 60 19640 60 {lab=reset_release_0}
N 23040 1340 23040 90 {lab=start_sync_0}
N 23040 1340 23080 1340 {lab=start_sync_0}
N 23080 1340 23080 1370 {lab=start_sync_0}
N 23080 1370 23360 1370 {lab=start_sync_0}
N 23040 90 23080 90 {lab=start_sync_0}
N 23080 90 23080 60 {lab=start_sync_0}
N 23080 60 23360 60 {lab=start_sync_0}
N 40480 1340 40480 1290 {lab=149.net_0}
N 40480 1290 40680 1290 {lab=149.net_0}
N 40480 1290 40480 1250 {lab=149.net_0}
N 40680 1290 40680 1250 {lab=149.net_0}
N 40680 1290 40680 1340 {lab=149.net_0}
N 17440 1340 17440 1250 {lab=251.net10}
N 17440 1250 17490 1250 {lab=251.net10}
N 17490 1250 17490 180 {lab=251.net10}
N 17490 180 17440 180 {lab=251.net10}
N 17440 180 17440 90 {lab=251.net10}
N 18960 1250 18960 1340 {lab=251.net11}
N 18960 1250 19010 1250 {lab=251.net11}
N 19010 1250 19010 180 {lab=251.net11}
N 19010 180 18960 180 {lab=251.net11}
N 18960 180 18960 90 {lab=251.net11}
N 19680 1340 19680 1250 {lab=252.net10}
N 19680 1250 19730 1250 {lab=252.net10}
N 19730 1250 19730 180 {lab=252.net10}
N 19730 180 19680 180 {lab=252.net10}
N 19680 180 19680 90 {lab=252.net10}
N 21200 1250 21200 1340 {lab=252.net11}
N 21200 1250 21240 1250 {lab=252.net11}
N 21240 1250 21240 180 {lab=252.net11}
N 21240 180 21200 180 {lab=252.net11}
N 21200 180 21200 90 {lab=252.net11}
N 12200 1340 12200 1260 {lab=253.net10}
N 12200 1260 12140 1260 {lab=253.net10}
N 12200 1260 12200 1250 {lab=253.net10}
N 12140 1260 12140 170 {lab=253.net10}
N 12140 170 12200 170 {lab=253.net10}
N 12200 170 12200 90 {lab=253.net10}
N 12200 170 12200 180 {lab=253.net10}
N 22680 1250 22680 1340 {lab=253.net11}
N 22680 1250 22730 1250 {lab=253.net11}
N 22730 1250 22730 180 {lab=253.net11}
N 22730 180 22680 180 {lab=253.net11}
N 22680 180 22680 90 {lab=253.net11}
N 23400 1340 23400 1250 {lab=254.net10}
N 23400 1250 23450 1250 {lab=254.net10}
N 23450 1250 23450 180 {lab=254.net10}
N 23450 180 23400 180 {lab=254.net10}
N 23400 180 23400 90 {lab=254.net10}
N 24920 1250 24920 1340 {lab=254.net11}
N 24920 1250 24970 1250 {lab=254.net11}
N 24970 1250 24970 180 {lab=254.net11}
N 24970 180 24920 180 {lab=254.net11}
N 24920 180 24920 90 {lab=254.net11}
N 25640 1340 25640 1250 {lab=255.net10}
N 25640 1250 25700 1250 {lab=255.net10}
N 25700 1250 25700 180 {lab=255.net10}
N 25700 180 25640 180 {lab=255.net10}
N 25640 180 25640 90 {lab=255.net10}
N 27160 1250 27160 1340 {lab=255.net11}
N 27160 1250 27200 1250 {lab=255.net11}
N 27200 1250 27200 180 {lab=255.net11}
N 27200 180 27160 180 {lab=255.net11}
N 27160 180 27160 90 {lab=255.net11}
N 56960 1340 56960 1250 {lab=256.net10}
N 56960 1250 57000 1250 {lab=256.net10}
N 57000 1250 57000 180 {lab=256.net10}
N 57000 180 56960 180 {lab=256.net10}
N 56960 180 56960 90 {lab=256.net10}
N 57920 1250 57920 1340 {lab=256.net11}
N 57920 1250 57970 1250 {lab=256.net11}
N 57970 1250 57970 180 {lab=256.net11}
N 57970 180 57920 180 {lab=256.net11}
N 57920 180 57920 90 {lab=256.net11}
N 58280 1340 58280 1250 {lab=257.net10}
N 58280 1250 58320 1250 {lab=257.net10}
N 58320 1250 58320 180 {lab=257.net10}
N 58320 180 58280 180 {lab=257.net10}
N 58280 180 58280 90 {lab=257.net10}
N 59240 1250 59240 1340 {lab=257.net11}
N 59240 1250 59300 1250 {lab=257.net11}
N 59300 1250 59300 180 {lab=257.net11}
N 59300 180 59240 180 {lab=257.net11}
N 59240 180 59240 90 {lab=257.net11}
N 59600 1340 59600 1250 {lab=258.net10}
N 59600 1250 59640 1250 {lab=258.net10}
N 59640 1250 59640 180 {lab=258.net10}
N 59640 180 59600 180 {lab=258.net10}
N 59600 180 59600 90 {lab=258.net10}
N 60560 1250 60560 1340 {lab=258.net11}
N 60560 1250 60610 1250 {lab=258.net11}
N 60610 1250 60610 180 {lab=258.net11}
N 60610 180 60560 180 {lab=258.net11}
N 60560 180 60560 90 {lab=258.net11}
N 60920 1340 60920 1250 {lab=278.net10}
N 60920 1250 60960 1250 {lab=278.net10}
N 60960 1250 60960 180 {lab=278.net10}
N 60960 180 60920 180 {lab=278.net10}
N 60920 180 60920 90 {lab=278.net10}
N 61880 1250 61880 1340 {lab=278.net11}
N 61880 1250 61940 1250 {lab=278.net11}
N 61940 1250 61940 180 {lab=278.net11}
N 61940 180 61880 180 {lab=278.net11}
N 61880 180 61880 90 {lab=278.net11}
N 62240 1340 62240 1250 {lab=279.net10}
N 62240 1250 62280 1250 {lab=279.net10}
N 62280 1250 62280 180 {lab=279.net10}
N 62280 180 62240 180 {lab=279.net10}
N 62240 180 62240 90 {lab=279.net10}
N 63200 1250 63200 1340 {lab=279.net11}
N 63200 1250 63260 1250 {lab=279.net11}
N 63260 1250 63260 180 {lab=279.net11}
N 63260 180 63200 180 {lab=279.net11}
N 63200 180 63200 90 {lab=279.net11}
N 63560 1340 63560 1250 {lab=280.net10}
N 63560 1250 63600 1250 {lab=280.net10}
N 63600 1250 63600 180 {lab=280.net10}
N 63600 180 63560 180 {lab=280.net10}
N 63560 180 63560 90 {lab=280.net10}
N 64520 1250 64580 1250 {lab=280.net11}
N 64520 1250 64520 1340 {lab=280.net11}
N 64580 1250 64580 180 {lab=280.net11}
N 64580 180 64520 180 {lab=280.net11}
N 64520 180 64520 90 {lab=280.net11}
N 16640 1070 16630 1070 {lab=uio_in_6}
N 16630 1070 16630 1020 {lab=uio_in_6}
N 16630 1020 16920 1020 {lab=uio_in_6}
N 16920 1020 16920 60 {lab=uio_in_6}
N 16920 60 16920 -20 {lab=uio_in_6}
N 16920 60 17040 60 {lab=uio_in_6}
N 16920 -20 -80 -20 {lab=uio_in_6}
N -80 -20 -80 1050 {lab=uio_in_6}
N -80 1050 -60 1050 {lab=uio_in_6}
N 15880 1070 15870 1070 {lab=ui_in_3}
N 15870 1070 15870 1020 {lab=ui_in_3}
N 15870 1020 16160 1020 {lab=ui_in_3}
N 16160 1020 16160 60 {lab=ui_in_3}
N 16160 60 16160 -30 {lab=ui_in_3}
N 16160 60 16280 60 {lab=ui_in_3}
N 16160 -30 -90 -30 {lab=ui_in_3}
N -90 -30 -90 970 {lab=ui_in_3}
N -90 970 -60 970 {lab=ui_in_3}
N 12160 1370 12130 1370 {lab=ui_in_4}
N 12130 1370 12130 1430 {lab=ui_in_4}
N 12130 1370 12130 60 {lab=ui_in_4}
N 12130 60 12160 60 {lab=ui_in_4}
N 12130 1430 11060 1430 {lab=ui_in_4}
N 11060 1430 11060 1500 {lab=ui_in_4}
N 11060 1500 1070 1500 {lab=ui_in_4}
N 1070 1500 1070 1010 {lab=ui_in_4}
N 1070 1010 -60 1010 {lab=ui_in_4}
N 17400 1370 17380 1370 {lab=tie_hi_z}
N 17380 1370 17380 130 {lab=tie_hi_z}
N 17380 130 11840 130 {lab=tie_hi_z}
N 17380 130 17380 60 {lab=tie_hi_z}
N 17380 60 17400 60 {lab=tie_hi_z}
N 11840 130 11840 90 {lab=tie_hi_z}
N 2600 1370 2590 1370 {lab=trials_0}
N 2590 1370 2590 880 {lab=trials_0}
N 2590 880 1980 880 {lab=trials_0}
N 1980 880 1980 650 {lab=trials_0}
N 1980 650 1980 510 {lab=trials_0}
N 1980 650 -60 650 {lab=trials_0}
N 1980 510 2000 510 {lab=trials_0}
N 1640 1370 1630 1370 {lab=trials_7}
N 1630 1370 1630 960 {lab=trials_7}
N 1630 960 -60 960 {lab=trials_7}
N 1630 960 1630 60 {lab=trials_7}
N 1630 60 1640 60 {lab=trials_7}
N -60 960 -60 930 {lab=trials_7}
N 1080 1220 1060 1220 {lab=trials_1}
N 1060 1220 1060 1180 {lab=trials_1}
N 1060 1180 1160 1180 {lab=trials_1}
N 1160 1180 1160 690 {lab=trials_1}
N 1160 690 -60 690 {lab=trials_1}
N 1160 690 1160 60 {lab=trials_1}
N 1160 60 1280 60 {lab=trials_1}
N 1080 1370 1050 1370 {lab=trials_6}
N 1050 1370 1050 880 {lab=trials_6}
N 1050 880 1050 60 {lab=trials_6}
N 1050 880 -60 880 {lab=trials_6}
N 1050 60 1080 60 {lab=trials_6}
N -60 880 -60 890 {lab=trials_6}
N 120 920 -70 920 {lab=trials_2}
N -70 920 -70 730 {lab=trials_2}
N -70 730 -70 560 {lab=trials_2}
N -70 730 -60 730 {lab=trials_2}
N -70 560 600 560 {lab=trials_2}
N 600 560 600 60 {lab=trials_2}
N 600 60 720 60 {lab=trials_2}
N 120 1070 110 1070 {lab=trials_3}
N 110 1070 110 770 {lab=trials_3}
N 110 770 -60 770 {lab=trials_3}
N 110 770 400 770 {lab=trials_3}
N 400 770 400 60 {lab=trials_3}
N 400 60 520 60 {lab=trials_3}
N 120 1220 100 1220 {lab=trials_4}
N 100 1220 100 810 {lab=trials_4}
N 100 810 200 810 {lab=trials_4}
N 100 810 -60 810 {lab=trials_4}
N 200 810 200 60 {lab=trials_4}
N 200 60 320 60 {lab=trials_4}
N 11480 1340 11480 1330 {lab=tie_hi.A}
N 11480 1330 11480 60 {lab=tie_hi.A}
N 11480 1330 11430 1330 {lab=tie_hi.A}
N 11430 1330 11430 1370 {lab=tie_hi.A}
N 11430 1370 11440 1370 {lab=tie_hi.A}
N 11480 60 11800 60 {lab=tie_hi.A}
N 37080 180 37080 170 {lab=143.net_1}
N 37080 170 37280 170 {lab=143.net_1}
N 37080 170 37080 90 {lab=143.net_1}
N 37280 170 37280 180 {lab=143.net_1}
N 39920 180 39920 170 {lab=148.net_1}
N 39920 170 39920 90 {lab=148.net_1}
N 39920 170 40120 170 {lab=148.net_1}
N 40120 170 40120 180 {lab=148.net_1}
N 50240 1250 50240 1270 {lab=232.net_0}
N 50240 1270 50240 1340 {lab=232.net_0}
N 50240 1270 50440 1270 {lab=232.net_0}
N 50440 1270 50440 1250 {lab=232.net_0}
N 51720 1250 51720 1310 {lab=234.net_0}
N 51720 1310 51720 1340 {lab=234.net_0}
N 51720 1310 51920 1310 {lab=234.net_0}
N 51920 1310 51920 1250 {lab=234.net_0}
N 52280 1250 52280 1290 {lab=235.net_0}
N 52280 1290 52280 1340 {lab=235.net_0}
N 52280 1290 52480 1290 {lab=235.net_0}
N 52480 1290 52480 1250 {lab=235.net_0}
N 55840 180 55840 170 {lab=240.net_1}
N 55840 170 56040 170 {lab=240.net_1}
N 55840 170 55840 90 {lab=240.net_1}
N 56040 170 56040 180 {lab=240.net_1}
N 17840 180 17840 110 {lab=251.net9}
N 17840 110 17640 110 {lab=251.net9}
N 17840 110 17840 90 {lab=251.net9}
N 17640 110 17640 90 {lab=251.net9}
N 20080 180 20080 110 {lab=252.net9}
N 20080 110 19880 110 {lab=252.net9}
N 20080 110 20080 90 {lab=252.net9}
N 19880 110 19880 90 {lab=252.net9}
N 12600 180 12600 100 {lab=253.net9}
N 12600 100 12400 100 {lab=253.net9}
N 12600 100 12600 90 {lab=253.net9}
N 12400 100 12400 90 {lab=253.net9}
N 23800 180 23800 110 {lab=254.net9}
N 23800 110 23600 110 {lab=254.net9}
N 23800 110 23800 90 {lab=254.net9}
N 23600 110 23600 90 {lab=254.net9}
N 26040 180 26040 110 {lab=255.net9}
N 26040 110 25840 110 {lab=255.net9}
N 26040 110 26040 90 {lab=255.net9}
N 25840 110 25840 90 {lab=255.net9}
N 57360 180 57360 100 {lab=256.net9}
N 57360 100 57360 90 {lab=256.net9}
N 57360 100 57160 100 {lab=256.net9}
N 57160 100 57160 90 {lab=256.net9}
N 58680 180 58680 100 {lab=257.net9}
N 58680 100 58680 90 {lab=257.net9}
N 58680 100 58480 100 {lab=257.net9}
N 58480 100 58480 90 {lab=257.net9}
N 60000 180 60000 100 {lab=258.net9}
N 60000 100 59800 100 {lab=258.net9}
N 60000 100 60000 90 {lab=258.net9}
N 59800 100 59800 90 {lab=258.net9}
N 61320 180 61320 100 {lab=278.net9}
N 61320 100 61320 90 {lab=278.net9}
N 61320 100 61120 100 {lab=278.net9}
N 61120 100 61120 90 {lab=278.net9}
N 62640 180 62640 120 {lab=279.net9}
N 62640 120 62640 90 {lab=279.net9}
N 62640 120 62440 120 {lab=279.net9}
N 62440 120 62440 90 {lab=279.net9}
N 63960 180 63960 100 {lab=280.net9}
N 63960 100 63910 100 {lab=280.net9}
N 63960 100 63960 90 {lab=280.net9}
N 63910 100 63910 90 {lab=280.net9}
N 63910 90 63760 90 {lab=280.net9}
N 120 1370 90 1370 {lab=trials_5}
N 90 1370 90 850 {lab=trials_5}
N 90 850 90 60 {lab=trials_5}
N 90 850 -60 850 {lab=trials_5}
N 90 60 120 60 {lab=trials_5}
N 12960 1250 12960 1340 {lab=132.net_0}
N 13880 1340 13880 1250 {lab=133.net_0}
N 33920 90 33920 180 {lab=134.net_0}
N 35760 90 35760 180 {lab=141.net_1}
N 35760 240 35760 330 {lab=141.net_0}
N 36520 1340 36520 1250 {lab=142.net_0}
N 37080 1340 37080 1250 {lab=143.net_0}
N 37640 1340 37640 1250 {lab=144.net_1}
N 37640 1190 37640 1100 {lab=144.net_0}
N 38400 90 38400 180 {lab=145.net_1}
N 38400 240 38400 330 {lab=145.net_0}
N 39160 90 39160 180 {lab=147.net_1}
N 39160 240 39160 330 {lab=147.net_0}
N 39920 1340 39920 1250 {lab=148.net_0}
N 40480 90 40480 180 {lab=149.net_2}
N 40680 180 40680 90 {lab=149.net_1}
N 41040 90 41040 180 {lab=150.net_2}
N 41040 240 41040 330 {lab=150.net_1}
N 41040 390 41040 480 {lab=150.net_0}
N 42000 1340 42000 1250 {lab=151.net_0}
N 42560 180 42560 90 {lab=152.net_0}
N 14440 1250 14440 1340 {lab=153.net_0}
N 43480 90 43480 180 {lab=155.net_1}
N 43480 240 43480 330 {lab=155.net_0}
N 15360 90 15360 180 {lab=157.net_0}
N 160 1340 160 1250 {lab=158.net_2}
N 160 1190 160 1100 {lab=158.net_1}
N 160 1040 160 950 {lab=158.net_0}
N 1120 1340 1120 1250 {lab=159.net_0}
N 2040 90 2040 180 {lab=160.net_2}
N 2040 240 2040 330 {lab=160.net_1}
N 2040 390 2040 480 {lab=160.net_0}
N 44240 90 44240 180 {lab=163.net_0}
N 44800 1340 44800 1250 {lab=164.net_0}
N 45360 1340 45360 1250 {lab=165.net_0}
N 15920 1340 15920 1250 {lab=166.net_1}
N 15920 1190 15920 1100 {lab=166.net_0}
N 45920 1340 45920 1250 {lab=167.net_0}
N 46480 1340 46480 1250 {lab=168.net_0}
N 16680 1340 16680 1250 {lab=169.net_1}
N 16680 1190 16680 1100 {lab=169.net_0}
N 47040 1340 47040 1250 {lab=170.net_0}
N 47600 1340 47600 1250 {lab=227.net_2}
N 47600 1190 47600 1100 {lab=227.net_1}
N 47600 1040 47600 950 {lab=227.net_0}
N 48560 90 48560 180 {lab=228.net_0}
N 49120 1340 49120 1250 {lab=229.net_0}
N 3000 90 3000 180 {lab=230.net_0}
N 49680 1340 49680 1250 {lab=231.net_0}
N 50240 90 50240 180 {lab=232.net_1}
N 50800 1250 50800 1340 {lab=233.net_0}
N 51720 90 51720 180 {lab=234.net_1}
N 52280 90 52280 180 {lab=235.net_1}
N 52840 1100 52840 1190 {lab=236.net_0}
N 52840 1250 52840 1340 {lab=236.net_1}
N 53960 90 53960 180 {lab=237.net_0}
N 54520 1340 54520 1250 {lab=238.net_1}
N 54520 1190 54520 1100 {lab=238.net_0}
N 55280 1340 55280 1250 {lab=239.net_0}
N 55840 1340 55840 1250 {lab=240.net_0}
N 56400 90 56400 180 {lab=241.net_0}
N 17640 1100 17640 1190 {lab=251.net15}
N 17640 1250 17640 1340 {lab=251.net12}
N 18200 1340 18200 1250 {lab=251.net0}
N 19880 1100 19880 1190 {lab=252.net15}
N 19880 1250 19880 1340 {lab=252.net12}
N 20440 1340 20440 1250 {lab=252.net0}
N 12400 1100 12400 1190 {lab=253.net15}
N 12400 1250 12400 1340 {lab=253.net12}
N 21920 1340 21920 1250 {lab=253.net0}
N 23600 1100 23600 1190 {lab=254.net15}
N 23600 1250 23600 1340 {lab=254.net12}
N 24160 1340 24160 1250 {lab=254.net0}
N 25840 1100 25840 1190 {lab=255.net15}
N 25840 1250 25840 1340 {lab=255.net12}
N 26400 1340 26400 1250 {lab=255.net0}
N 57160 1100 57160 1190 {lab=256.net15}
N 57160 1250 57160 1340 {lab=256.net12}
N 28240 1340 28240 1250 {lab=256.net0}
N 58480 1100 58480 1190 {lab=257.net15}
N 58480 1250 58480 1340 {lab=257.net12}
N 29520 1340 29520 1250 {lab=257.net0}
N 59800 1100 59800 1190 {lab=258.net15}
N 59800 1250 59800 1340 {lab=258.net12}
N 30440 1340 30440 1250 {lab=258.net0}
N 61120 1100 61120 1190 {lab=278.net15}
N 61120 1250 61120 1340 {lab=278.net12}
N 31360 1340 31360 1250 {lab=278.net0}
N 62440 1100 62440 1190 {lab=279.net15}
N 62440 1250 62440 1340 {lab=279.net12}
N 32640 1340 32640 1250 {lab=279.net0}
N 63760 1100 63760 1190 {lab=280.net15}
N 63760 1250 63760 1340 {lab=280.net12}
N 34480 1340 34480 1250 {lab=280.net0}
C {devices/ipin.sym} -60 490 0 0 {name=p924 lab=clk}
C {devices/ipin.sym} -60 530 0 0 {name=p925 lab=ena}
C {devices/ipin.sym} -60 570 0 0 {name=p926 lab=reference_fault}
C {devices/ipin.sym} -60 610 0 0 {name=p927 lab=rst_n}
C {devices/ipin.sym} -60 650 0 0 {name=p928 lab=trials_0}
C {devices/ipin.sym} -60 690 0 0 {name=p929 lab=trials_1}
C {devices/ipin.sym} -60 730 0 0 {name=p930 lab=trials_2}
C {devices/ipin.sym} -60 770 0 0 {name=p931 lab=trials_3}
C {devices/ipin.sym} -60 810 0 0 {name=p932 lab=trials_4}
C {devices/ipin.sym} -60 850 0 0 {name=p933 lab=trials_5}
C {devices/ipin.sym} -60 890 0 0 {name=p934 lab=trials_6}
C {devices/ipin.sym} -60 930 0 0 {name=p935 lab=trials_7}
C {devices/ipin.sym} -60 970 0 0 {name=p936 lab=ui_in_3}
C {devices/ipin.sym} -60 1010 0 0 {name=p937 lab=ui_in_4}
C {devices/ipin.sym} -60 1050 0 0 {name=p938 lab=uio_in_6}
C {devices/opin.sym} 64900 350 0 0 {name=p939 lab=_031_}
C {devices/opin.sym} 64900 390 0 0 {name=p940 lab=_034_}
C {devices/opin.sym} 64900 430 0 0 {name=p941 lab=_035_}
C {devices/opin.sym} 64900 470 0 0 {name=p942 lab=_086_}
C {devices/opin.sym} 64900 510 0 0 {name=p943 lab=_096_}
C {devices/opin.sym} 64900 550 0 0 {name=p944 lab=_101_}
C {devices/opin.sym} 64900 590 0 0 {name=p945 lab=_102_}
C {devices/opin.sym} 64900 630 0 0 {name=p946 lab=_103_}
C {devices/opin.sym} 64900 670 0 0 {name=p947 lab=_111_}
C {devices/opin.sym} 64900 710 0 0 {name=p948 lab=_113_}
C {devices/opin.sym} 64900 750 0 0 {name=p949 lab=_115_}
C {devices/opin.sym} 64900 790 0 0 {name=p950 lab=_117_}
C {devices/opin.sym} 64900 830 0 0 {name=p951 lab=_119_}
C {devices/opin.sym} 64900 870 0 0 {name=p952 lab=_120_}
C {devices/opin.sym} 64900 910 0 0 {name=p953 lab=_122_}
C {devices/opin.sym} 64900 950 0 0 {name=p954 lab=_124_}
C {devices/opin.sym} 64900 990 0 0 {name=p955 lab=capture}
C {devices/opin.sym} 64900 1030 0 0 {name=p956 lab=cfg_0}
C {devices/opin.sym} 64900 1070 0 0 {name=p957 lab=cfg_1}
C {devices/opin.sym} 64900 1110 0 0 {name=p958 lab=state_0}
C {devices/opin.sym} 64900 1150 0 0 {name=p959 lab=state_1}
C {devices/opin.sym} 64900 1190 0 0 {name=p960 lab=state_2}
