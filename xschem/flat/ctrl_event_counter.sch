v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {ctrl_event_counter: controller block "event_counter" at transistor level (32 cells)} 0 -230 0 0 0.45 0.45 {}
T {Event counter k: bit 0 takes k_0 XOR event_bit on each count; each later bit is clocked by the bit below} 0 -190 0 0 0.26 0.26 {}
T {From src/gf180/compact_control.v; every cell opened up. Stage labels are the cell instance names.} 0 -162 0 0 0.26 0.26 {}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44900 920 0 0 {name=Mk10_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45260 920 0 0 {name=Mk10_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45980 920 0 0 {name=Mk10_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45980 770 0 0 {name=Mk10_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46180 620 0 0 {name=Mk10_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46180 770 0 0 {name=Mk10_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46180 920 0 0 {name=Mk10_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46740 920 0 0 {name=Mk10_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46740 770 0 0 {name=Mk10_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46940 770 0 0 {name=Mk10_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46940 920 0 0 {name=Mk10_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 860 920 0 0 {name=Mk10_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 860 770 0 0 {name=Mk10_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1420 920 0 0 {name=Mk10_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44900 60 0 0 {name=Mk10_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45260 60 0 0 {name=Mk10_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45980 60 0 0 {name=Mk10_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45980 210 0 0 {name=Mk10_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46380 210 0 0 {name=Mk10_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46180 60 0 0 {name=Mk10_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46380 60 0 0 {name=Mk10_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46740 60 0 0 {name=Mk10_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46740 210 0 0 {name=Mk10_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46940 210 0 0 {name=Mk10_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46940 60 0 0 {name=Mk10_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 860 60 0 0 {name=Mk10_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1060 60 0 0 {name=Mk10_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1420 60 0 0 {name=Mk10_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1780 920 0 0 {name=Mk10_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1780 60 0 0 {name=Mk10_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2140 920 0 0 {name=Mk11_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2500 920 0 0 {name=Mk11_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4860 920 0 0 {name=Mk11_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4860 770 0 0 {name=Mk11_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5060 620 0 0 {name=Mk11_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5060 770 0 0 {name=Mk11_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5060 920 0 0 {name=Mk11_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5620 920 0 0 {name=Mk11_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5620 770 0 0 {name=Mk11_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5820 770 0 0 {name=Mk11_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5820 920 0 0 {name=Mk11_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2860 920 0 0 {name=Mk11_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2860 770 0 0 {name=Mk11_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3420 920 0 0 {name=Mk11_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2140 60 0 0 {name=Mk11_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2500 60 0 0 {name=Mk11_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4860 60 0 0 {name=Mk11_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4860 210 0 0 {name=Mk11_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5260 210 0 0 {name=Mk11_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5060 60 0 0 {name=Mk11_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5260 60 0 0 {name=Mk11_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5620 60 0 0 {name=Mk11_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5620 210 0 0 {name=Mk11_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5820 210 0 0 {name=Mk11_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5820 60 0 0 {name=Mk11_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2860 60 0 0 {name=Mk11_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3060 60 0 0 {name=Mk11_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3420 60 0 0 {name=Mk11_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3780 920 0 0 {name=Mk11_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3780 60 0 0 {name=Mk11_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4140 920 0 0 {name=Mk12_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4500 920 0 0 {name=Mk12_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8180 920 0 0 {name=Mk12_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8180 770 0 0 {name=Mk12_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8380 620 0 0 {name=Mk12_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8380 770 0 0 {name=Mk12_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8380 920 0 0 {name=Mk12_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8940 920 0 0 {name=Mk12_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8940 770 0 0 {name=Mk12_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9140 770 0 0 {name=Mk12_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9140 920 0 0 {name=Mk12_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6180 920 0 0 {name=Mk12_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6180 770 0 0 {name=Mk12_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6740 920 0 0 {name=Mk12_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4140 60 0 0 {name=Mk12_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4500 60 0 0 {name=Mk12_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8180 60 0 0 {name=Mk12_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8180 210 0 0 {name=Mk12_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8580 210 0 0 {name=Mk12_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8380 60 0 0 {name=Mk12_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8580 60 0 0 {name=Mk12_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8940 60 0 0 {name=Mk12_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8940 210 0 0 {name=Mk12_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9140 210 0 0 {name=Mk12_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9140 60 0 0 {name=Mk12_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6180 60 0 0 {name=Mk12_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6380 60 0 0 {name=Mk12_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6740 60 0 0 {name=Mk12_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7100 920 0 0 {name=Mk12_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7100 60 0 0 {name=Mk12_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7460 920 0 0 {name=Mk13_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7820 920 0 0 {name=Mk13_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11500 920 0 0 {name=Mk13_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11500 770 0 0 {name=Mk13_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11700 620 0 0 {name=Mk13_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11700 770 0 0 {name=Mk13_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11700 920 0 0 {name=Mk13_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12260 920 0 0 {name=Mk13_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12260 770 0 0 {name=Mk13_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12460 770 0 0 {name=Mk13_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12460 920 0 0 {name=Mk13_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9500 920 0 0 {name=Mk13_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9500 770 0 0 {name=Mk13_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10060 920 0 0 {name=Mk13_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7460 60 0 0 {name=Mk13_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7820 60 0 0 {name=Mk13_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11500 60 0 0 {name=Mk13_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11500 210 0 0 {name=Mk13_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11900 210 0 0 {name=Mk13_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11700 60 0 0 {name=Mk13_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11900 60 0 0 {name=Mk13_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12260 60 0 0 {name=Mk13_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12260 210 0 0 {name=Mk13_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12460 210 0 0 {name=Mk13_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12460 60 0 0 {name=Mk13_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9500 60 0 0 {name=Mk13_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9700 60 0 0 {name=Mk13_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10060 60 0 0 {name=Mk13_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10420 920 0 0 {name=Mk13_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10420 60 0 0 {name=Mk13_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10780 920 0 0 {name=Mk14_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11140 920 0 0 {name=Mk14_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14820 920 0 0 {name=Mk14_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14820 770 0 0 {name=Mk14_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15020 620 0 0 {name=Mk14_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15020 770 0 0 {name=Mk14_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15020 920 0 0 {name=Mk14_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15580 920 0 0 {name=Mk14_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15580 770 0 0 {name=Mk14_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15780 770 0 0 {name=Mk14_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15780 920 0 0 {name=Mk14_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12820 920 0 0 {name=Mk14_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12820 770 0 0 {name=Mk14_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13380 920 0 0 {name=Mk14_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10780 60 0 0 {name=Mk14_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11140 60 0 0 {name=Mk14_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14820 60 0 0 {name=Mk14_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14820 210 0 0 {name=Mk14_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15220 210 0 0 {name=Mk14_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15020 60 0 0 {name=Mk14_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15220 60 0 0 {name=Mk14_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15580 60 0 0 {name=Mk14_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15580 210 0 0 {name=Mk14_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15780 210 0 0 {name=Mk14_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15780 60 0 0 {name=Mk14_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12820 60 0 0 {name=Mk14_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13020 60 0 0 {name=Mk14_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13380 60 0 0 {name=Mk14_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13740 920 0 0 {name=Mk14_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13740 60 0 0 {name=Mk14_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14100 920 0 0 {name=Mk15_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14460 920 0 0 {name=Mk15_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17420 920 0 0 {name=Mk15_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17420 770 0 0 {name=Mk15_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17620 620 0 0 {name=Mk15_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17620 770 0 0 {name=Mk15_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17620 920 0 0 {name=Mk15_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18180 920 0 0 {name=Mk15_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18180 770 0 0 {name=Mk15_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18380 770 0 0 {name=Mk15_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18380 920 0 0 {name=Mk15_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16140 920 0 0 {name=Mk15_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16140 770 0 0 {name=Mk15_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16700 920 0 0 {name=Mk15_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14100 60 0 0 {name=Mk15_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14460 60 0 0 {name=Mk15_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17420 60 0 0 {name=Mk15_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17420 210 0 0 {name=Mk15_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17820 210 0 0 {name=Mk15_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17620 60 0 0 {name=Mk15_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17820 60 0 0 {name=Mk15_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18180 60 0 0 {name=Mk15_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18180 210 0 0 {name=Mk15_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18380 210 0 0 {name=Mk15_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18380 60 0 0 {name=Mk15_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16140 60 0 0 {name=Mk15_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16340 60 0 0 {name=Mk15_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16700 60 0 0 {name=Mk15_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17060 920 0 0 {name=Mk15_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17060 60 0 0 {name=Mk15_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50660 920 0 0 {name=Mk1_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51020 920 0 0 {name=Mk1_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51380 920 0 0 {name=Mk1_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51380 770 0 0 {name=Mk1_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51580 620 0 0 {name=Mk1_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51580 770 0 0 {name=Mk1_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51580 920 0 0 {name=Mk1_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52140 920 0 0 {name=Mk1_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52140 770 0 0 {name=Mk1_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52340 770 0 0 {name=Mk1_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52340 920 0 0 {name=Mk1_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18740 920 0 0 {name=Mk1_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18740 770 0 0 {name=Mk1_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19300 920 0 0 {name=Mk1_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50660 60 0 0 {name=Mk1_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51020 60 0 0 {name=Mk1_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51380 60 0 0 {name=Mk1_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51380 210 0 0 {name=Mk1_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51780 210 0 0 {name=Mk1_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51580 60 0 0 {name=Mk1_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51780 60 0 0 {name=Mk1_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52140 60 0 0 {name=Mk1_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52140 210 0 0 {name=Mk1_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52340 210 0 0 {name=Mk1_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52340 60 0 0 {name=Mk1_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18740 60 0 0 {name=Mk1_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18940 60 0 0 {name=Mk1_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19300 60 0 0 {name=Mk1_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19660 920 0 0 {name=Mk1_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19660 60 0 0 {name=Mk1_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20020 920 0 0 {name=Mk2_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20380 920 0 0 {name=Mk2_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22740 920 0 0 {name=Mk2_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22740 770 0 0 {name=Mk2_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22940 620 0 0 {name=Mk2_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22940 770 0 0 {name=Mk2_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22940 920 0 0 {name=Mk2_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23500 920 0 0 {name=Mk2_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23500 770 0 0 {name=Mk2_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23700 770 0 0 {name=Mk2_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23700 920 0 0 {name=Mk2_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20740 920 0 0 {name=Mk2_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20740 770 0 0 {name=Mk2_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21300 920 0 0 {name=Mk2_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20020 60 0 0 {name=Mk2_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20380 60 0 0 {name=Mk2_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22740 60 0 0 {name=Mk2_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22740 210 0 0 {name=Mk2_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23140 210 0 0 {name=Mk2_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22940 60 0 0 {name=Mk2_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23140 60 0 0 {name=Mk2_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23500 60 0 0 {name=Mk2_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23500 210 0 0 {name=Mk2_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23700 210 0 0 {name=Mk2_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23700 60 0 0 {name=Mk2_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20740 60 0 0 {name=Mk2_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20940 60 0 0 {name=Mk2_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21300 60 0 0 {name=Mk2_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21660 920 0 0 {name=Mk2_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21660 60 0 0 {name=Mk2_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22020 920 0 0 {name=Mk3_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22380 920 0 0 {name=Mk3_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26060 920 0 0 {name=Mk3_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26060 770 0 0 {name=Mk3_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26260 620 0 0 {name=Mk3_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26260 770 0 0 {name=Mk3_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26260 920 0 0 {name=Mk3_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26820 920 0 0 {name=Mk3_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26820 770 0 0 {name=Mk3_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27020 770 0 0 {name=Mk3_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27020 920 0 0 {name=Mk3_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24060 920 0 0 {name=Mk3_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24060 770 0 0 {name=Mk3_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24620 920 0 0 {name=Mk3_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22020 60 0 0 {name=Mk3_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22380 60 0 0 {name=Mk3_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26060 60 0 0 {name=Mk3_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26060 210 0 0 {name=Mk3_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26460 210 0 0 {name=Mk3_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26260 60 0 0 {name=Mk3_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26460 60 0 0 {name=Mk3_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26820 60 0 0 {name=Mk3_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26820 210 0 0 {name=Mk3_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27020 210 0 0 {name=Mk3_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27020 60 0 0 {name=Mk3_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24060 60 0 0 {name=Mk3_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24260 60 0 0 {name=Mk3_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24620 60 0 0 {name=Mk3_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24980 920 0 0 {name=Mk3_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24980 60 0 0 {name=Mk3_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25340 920 0 0 {name=Mk4_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25700 920 0 0 {name=Mk4_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29380 920 0 0 {name=Mk4_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29380 770 0 0 {name=Mk4_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29580 620 0 0 {name=Mk4_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29580 770 0 0 {name=Mk4_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29580 920 0 0 {name=Mk4_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30140 920 0 0 {name=Mk4_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30140 770 0 0 {name=Mk4_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30340 770 0 0 {name=Mk4_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30340 920 0 0 {name=Mk4_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27380 920 0 0 {name=Mk4_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27380 770 0 0 {name=Mk4_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27940 920 0 0 {name=Mk4_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25340 60 0 0 {name=Mk4_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25700 60 0 0 {name=Mk4_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29380 60 0 0 {name=Mk4_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29380 210 0 0 {name=Mk4_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29780 210 0 0 {name=Mk4_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29580 60 0 0 {name=Mk4_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29780 60 0 0 {name=Mk4_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30140 60 0 0 {name=Mk4_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30140 210 0 0 {name=Mk4_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30340 210 0 0 {name=Mk4_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30340 60 0 0 {name=Mk4_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27380 60 0 0 {name=Mk4_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27580 60 0 0 {name=Mk4_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27940 60 0 0 {name=Mk4_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28300 920 0 0 {name=Mk4_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28300 60 0 0 {name=Mk4_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28660 920 0 0 {name=Mk5_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29020 920 0 0 {name=Mk5_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32700 920 0 0 {name=Mk5_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32700 770 0 0 {name=Mk5_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32900 620 0 0 {name=Mk5_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32900 770 0 0 {name=Mk5_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32900 920 0 0 {name=Mk5_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33460 920 0 0 {name=Mk5_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33460 770 0 0 {name=Mk5_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33660 770 0 0 {name=Mk5_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33660 920 0 0 {name=Mk5_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30700 920 0 0 {name=Mk5_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30700 770 0 0 {name=Mk5_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31260 920 0 0 {name=Mk5_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28660 60 0 0 {name=Mk5_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29020 60 0 0 {name=Mk5_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32700 60 0 0 {name=Mk5_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32700 210 0 0 {name=Mk5_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33100 210 0 0 {name=Mk5_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32900 60 0 0 {name=Mk5_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33100 60 0 0 {name=Mk5_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33460 60 0 0 {name=Mk5_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33460 210 0 0 {name=Mk5_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33660 210 0 0 {name=Mk5_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33660 60 0 0 {name=Mk5_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30700 60 0 0 {name=Mk5_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30900 60 0 0 {name=Mk5_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31260 60 0 0 {name=Mk5_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31620 920 0 0 {name=Mk5_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31620 60 0 0 {name=Mk5_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31980 920 0 0 {name=Mk6_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32340 920 0 0 {name=Mk6_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36020 920 0 0 {name=Mk6_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36020 770 0 0 {name=Mk6_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36220 620 0 0 {name=Mk6_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36220 770 0 0 {name=Mk6_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36220 920 0 0 {name=Mk6_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36780 920 0 0 {name=Mk6_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36780 770 0 0 {name=Mk6_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36980 770 0 0 {name=Mk6_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36980 920 0 0 {name=Mk6_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34020 920 0 0 {name=Mk6_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34020 770 0 0 {name=Mk6_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34580 920 0 0 {name=Mk6_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31980 60 0 0 {name=Mk6_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32340 60 0 0 {name=Mk6_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36020 60 0 0 {name=Mk6_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36020 210 0 0 {name=Mk6_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36420 210 0 0 {name=Mk6_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36220 60 0 0 {name=Mk6_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36420 60 0 0 {name=Mk6_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36780 60 0 0 {name=Mk6_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36780 210 0 0 {name=Mk6_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36980 210 0 0 {name=Mk6_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36980 60 0 0 {name=Mk6_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34020 60 0 0 {name=Mk6_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34220 60 0 0 {name=Mk6_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34580 60 0 0 {name=Mk6_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34940 920 0 0 {name=Mk6_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34940 60 0 0 {name=Mk6_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35300 920 0 0 {name=Mk7_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35660 920 0 0 {name=Mk7_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39340 920 0 0 {name=Mk7_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39340 770 0 0 {name=Mk7_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39540 620 0 0 {name=Mk7_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39540 770 0 0 {name=Mk7_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39540 920 0 0 {name=Mk7_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40100 920 0 0 {name=Mk7_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40100 770 0 0 {name=Mk7_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40300 770 0 0 {name=Mk7_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40300 920 0 0 {name=Mk7_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37340 920 0 0 {name=Mk7_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37340 770 0 0 {name=Mk7_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37900 920 0 0 {name=Mk7_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35300 60 0 0 {name=Mk7_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35660 60 0 0 {name=Mk7_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39340 60 0 0 {name=Mk7_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39340 210 0 0 {name=Mk7_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39740 210 0 0 {name=Mk7_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39540 60 0 0 {name=Mk7_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39740 60 0 0 {name=Mk7_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40100 60 0 0 {name=Mk7_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40100 210 0 0 {name=Mk7_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40300 210 0 0 {name=Mk7_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40300 60 0 0 {name=Mk7_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37340 60 0 0 {name=Mk7_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37540 60 0 0 {name=Mk7_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37900 60 0 0 {name=Mk7_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38260 920 0 0 {name=Mk7_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38260 60 0 0 {name=Mk7_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38620 920 0 0 {name=Mk8_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38980 920 0 0 {name=Mk8_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42660 920 0 0 {name=Mk8_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42660 770 0 0 {name=Mk8_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42860 620 0 0 {name=Mk8_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42860 770 0 0 {name=Mk8_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42860 920 0 0 {name=Mk8_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43420 920 0 0 {name=Mk8_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43420 770 0 0 {name=Mk8_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43620 770 0 0 {name=Mk8_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43620 920 0 0 {name=Mk8_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40660 920 0 0 {name=Mk8_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40660 770 0 0 {name=Mk8_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41220 920 0 0 {name=Mk8_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38620 60 0 0 {name=Mk8_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38980 60 0 0 {name=Mk8_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42660 60 0 0 {name=Mk8_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42660 210 0 0 {name=Mk8_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43060 210 0 0 {name=Mk8_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42860 60 0 0 {name=Mk8_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43060 60 0 0 {name=Mk8_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43420 60 0 0 {name=Mk8_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43420 210 0 0 {name=Mk8_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43620 210 0 0 {name=Mk8_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43620 60 0 0 {name=Mk8_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40660 60 0 0 {name=Mk8_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40860 60 0 0 {name=Mk8_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41220 60 0 0 {name=Mk8_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41580 920 0 0 {name=Mk8_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41580 60 0 0 {name=Mk8_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41940 920 0 0 {name=Mk9_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42300 920 0 0 {name=Mk9_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47300 920 0 0 {name=Mk9_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47300 770 0 0 {name=Mk9_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47500 620 0 0 {name=Mk9_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47500 770 0 0 {name=Mk9_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47500 920 0 0 {name=Mk9_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48060 920 0 0 {name=Mk9_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48060 770 0 0 {name=Mk9_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48260 770 0 0 {name=Mk9_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48260 920 0 0 {name=Mk9_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43980 920 0 0 {name=Mk9_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43980 770 0 0 {name=Mk9_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44540 920 0 0 {name=Mk9_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41940 60 0 0 {name=Mk9_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42300 60 0 0 {name=Mk9_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47300 60 0 0 {name=Mk9_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47300 210 0 0 {name=Mk9_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47700 210 0 0 {name=Mk9_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47500 60 0 0 {name=Mk9_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47700 60 0 0 {name=Mk9_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48060 60 0 0 {name=Mk9_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48060 210 0 0 {name=Mk9_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48260 210 0 0 {name=Mk9_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48260 60 0 0 {name=Mk9_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43980 60 0 0 {name=Mk9_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44180 60 0 0 {name=Mk9_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44540 60 0 0 {name=Mk9_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45620 920 0 0 {name=Mk9_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45620 60 0 0 {name=Mk9_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 140 920 0 0 {name=Mk0_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 500 920 0 0 {name=Mk0_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52700 920 0 0 {name=Mk0_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52700 770 0 0 {name=Mk0_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52900 620 0 0 {name=Mk0_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52900 770 0 0 {name=Mk0_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52900 920 0 0 {name=Mk0_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53460 920 0 0 {name=Mk0_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53460 770 0 0 {name=Mk0_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53660 770 0 0 {name=Mk0_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53660 920 0 0 {name=Mk0_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48620 920 0 0 {name=Mk0_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48620 770 0 0 {name=Mk0_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49180 920 0 0 {name=Mk0_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 140 60 0 0 {name=Mk0_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 500 60 0 0 {name=Mk0_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52700 60 0 0 {name=Mk0_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52700 210 0 0 {name=Mk0_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53100 210 0 0 {name=Mk0_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52900 60 0 0 {name=Mk0_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53100 60 0 0 {name=Mk0_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53460 60 0 0 {name=Mk0_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53460 210 0 0 {name=Mk0_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53660 210 0 0 {name=Mk0_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53660 60 0 0 {name=Mk0_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48620 60 0 0 {name=Mk0_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48820 60 0 0 {name=Mk0_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49180 60 0 0 {name=Mk0_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49540 920 0 0 {name=Mk0_xor_i_6 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49740 920 0 0 {name=Mk0_xor_i_7 L=0.6u W=0.36u nf=1 m=1 ad=1.8e-13 as=1.8e-13 pd=1.72e-06 ps=1.72e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50100 920 0 0 {name=Mk0_xor_i_2 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50100 770 0 0 {name=Mk0_xor_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50300 920 0 0 {name=Mk0_xor_i_1 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49540 210 0 0 {name=Mk0_xor_i_8 L=0.5u W=0.56u nf=1 m=1 ad=2.8e-13 as=2.8e-13 pd=2.12e-06 ps=2.12e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49540 60 0 0 {name=Mk0_xor_i_9 L=0.5u W=0.56u nf=1 m=1 ad=2.8e-13 as=2.8e-13 pd=2.12e-06 ps=2.12e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50100 60 0 0 {name=Mk0_xor_i_5 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50100 210 0 0 {name=Mk0_xor_i_3 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50300 210 0 0 {name=Mk0_xor_i_4 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
T {k10_ff} 830 -35 0 0 0.3 0.3 {}
T {k10_inv} 1750 -35 0 0 0.3 0.3 {}
T {k11_ff} 2110 -35 0 0 0.3 0.3 {}
T {k11_inv} 3750 -35 0 0 0.3 0.3 {}
T {k12_ff} 4110 -35 0 0 0.3 0.3 {}
T {k12_inv} 7070 -35 0 0 0.3 0.3 {}
T {k13_ff} 7430 -35 0 0 0.3 0.3 {}
T {k13_inv} 10390 -35 0 0 0.3 0.3 {}
T {k14_ff} 10750 -35 0 0 0.3 0.3 {}
T {k14_inv} 13710 -35 0 0 0.3 0.3 {}
T {k15_ff} 14070 -35 0 0 0.3 0.3 {}
T {k15_inv} 17030 -35 0 0 0.3 0.3 {}
T {k1_ff} 18710 -35 0 0 0.3 0.3 {}
T {k1_inv} 19630 -35 0 0 0.3 0.3 {}
T {k2_ff} 19990 -35 0 0 0.3 0.3 {}
T {k2_inv} 21630 -35 0 0 0.3 0.3 {}
T {k3_ff} 21990 -35 0 0 0.3 0.3 {}
T {k3_inv} 24950 -35 0 0 0.3 0.3 {}
T {k4_ff} 25310 -35 0 0 0.3 0.3 {}
T {k4_inv} 28270 -35 0 0 0.3 0.3 {}
T {k5_ff} 28630 -35 0 0 0.3 0.3 {}
T {k5_inv} 31590 -35 0 0 0.3 0.3 {}
T {k6_ff} 31950 -35 0 0 0.3 0.3 {}
T {k6_inv} 34910 -35 0 0 0.3 0.3 {}
T {k7_ff} 35270 -35 0 0 0.3 0.3 {}
T {k7_inv} 38230 -35 0 0 0.3 0.3 {}
T {k8_ff} 38590 -35 0 0 0.3 0.3 {}
T {k8_inv} 41550 -35 0 0 0.3 0.3 {}
T {k9_ff} 41910 -35 0 0 0.3 0.3 {}
T {k9_inv} 45590 -35 0 0 0.3 0.3 {}
T {k0_ff} 110 -35 0 0 0.3 0.3 {}
T {k0_xor} 49510 -35 0 0 0.3 0.3 {}
N 44920 950 44920 970 {lab=0}
C {devices/gnd.sym} 44920 970 0 0 {name=s1 lab=0}
N 44920 920 44950 920 {lab=0}
C {devices/gnd.sym} 44950 920 0 0 {name=s2 lab=0}
N 45280 950 45280 970 {lab=0}
C {devices/gnd.sym} 45280 970 0 0 {name=s3 lab=0}
N 45280 920 45310 920 {lab=0}
C {devices/gnd.sym} 45310 920 0 0 {name=s4 lab=0}
N 46000 950 46000 970 {lab=0}
C {devices/gnd.sym} 46000 970 0 0 {name=s5 lab=0}
N 46000 920 46030 920 {lab=0}
C {devices/gnd.sym} 46030 920 0 0 {name=s6 lab=0}
N 46000 770 46030 770 {lab=0}
C {devices/gnd.sym} 46030 770 0 0 {name=s7 lab=0}
N 46200 620 46230 620 {lab=0}
C {devices/gnd.sym} 46230 620 0 0 {name=s8 lab=0}
N 46200 770 46230 770 {lab=0}
C {devices/gnd.sym} 46230 770 0 0 {name=s9 lab=0}
N 46200 950 46200 970 {lab=0}
C {devices/gnd.sym} 46200 970 0 0 {name=s10 lab=0}
N 46200 920 46230 920 {lab=0}
C {devices/gnd.sym} 46230 920 0 0 {name=s11 lab=0}
N 46760 950 46760 970 {lab=0}
C {devices/gnd.sym} 46760 970 0 0 {name=s12 lab=0}
N 46760 920 46790 920 {lab=0}
C {devices/gnd.sym} 46790 920 0 0 {name=s13 lab=0}
N 46760 770 46790 770 {lab=0}
C {devices/gnd.sym} 46790 770 0 0 {name=s14 lab=0}
N 46960 770 46990 770 {lab=0}
C {devices/gnd.sym} 46990 770 0 0 {name=s15 lab=0}
N 46960 950 46960 970 {lab=0}
C {devices/gnd.sym} 46960 970 0 0 {name=s16 lab=0}
N 46960 920 46990 920 {lab=0}
C {devices/gnd.sym} 46990 920 0 0 {name=s17 lab=0}
N 880 950 880 970 {lab=0}
C {devices/gnd.sym} 880 970 0 0 {name=s18 lab=0}
N 880 920 910 920 {lab=0}
C {devices/gnd.sym} 910 920 0 0 {name=s19 lab=0}
N 880 770 910 770 {lab=0}
C {devices/gnd.sym} 910 770 0 0 {name=s20 lab=0}
N 1440 950 1440 970 {lab=0}
C {devices/gnd.sym} 1440 970 0 0 {name=s21 lab=0}
N 1440 920 1470 920 {lab=0}
C {devices/gnd.sym} 1470 920 0 0 {name=s22 lab=0}
N 44920 30 44920 10 {lab=VDD}
C {devices/vdd.sym} 44920 10 0 0 {name=s23 lab=VDD}
N 44920 60 44950 60 {lab=VDD}
C {devices/vdd.sym} 44950 60 0 0 {name=s24 lab=VDD}
N 45280 30 45280 10 {lab=VDD}
C {devices/vdd.sym} 45280 10 0 0 {name=s25 lab=VDD}
N 45280 60 45310 60 {lab=VDD}
C {devices/vdd.sym} 45310 60 0 0 {name=s26 lab=VDD}
N 46000 30 46000 10 {lab=VDD}
C {devices/vdd.sym} 46000 10 0 0 {name=s27 lab=VDD}
N 46000 60 46030 60 {lab=VDD}
C {devices/vdd.sym} 46030 60 0 0 {name=s28 lab=VDD}
N 46000 210 46030 210 {lab=VDD}
C {devices/vdd.sym} 46030 210 0 0 {name=s29 lab=VDD}
N 46400 210 46430 210 {lab=VDD}
C {devices/vdd.sym} 46430 210 0 0 {name=s30 lab=VDD}
N 46200 30 46200 10 {lab=VDD}
C {devices/vdd.sym} 46200 10 0 0 {name=s31 lab=VDD}
N 46200 60 46230 60 {lab=VDD}
C {devices/vdd.sym} 46230 60 0 0 {name=s32 lab=VDD}
N 46400 30 46400 10 {lab=VDD}
C {devices/vdd.sym} 46400 10 0 0 {name=s33 lab=VDD}
N 46400 60 46430 60 {lab=VDD}
C {devices/vdd.sym} 46430 60 0 0 {name=s34 lab=VDD}
N 46760 30 46760 10 {lab=VDD}
C {devices/vdd.sym} 46760 10 0 0 {name=s35 lab=VDD}
N 46760 60 46790 60 {lab=VDD}
C {devices/vdd.sym} 46790 60 0 0 {name=s36 lab=VDD}
N 46760 210 46790 210 {lab=VDD}
C {devices/vdd.sym} 46790 210 0 0 {name=s37 lab=VDD}
N 46960 210 46990 210 {lab=VDD}
C {devices/vdd.sym} 46990 210 0 0 {name=s38 lab=VDD}
N 46960 30 46960 10 {lab=VDD}
C {devices/vdd.sym} 46960 10 0 0 {name=s39 lab=VDD}
N 46960 60 46990 60 {lab=VDD}
C {devices/vdd.sym} 46990 60 0 0 {name=s40 lab=VDD}
N 880 30 880 10 {lab=VDD}
C {devices/vdd.sym} 880 10 0 0 {name=s41 lab=VDD}
N 880 60 910 60 {lab=VDD}
C {devices/vdd.sym} 910 60 0 0 {name=s42 lab=VDD}
N 1080 30 1080 10 {lab=VDD}
C {devices/vdd.sym} 1080 10 0 0 {name=s43 lab=VDD}
N 1080 60 1110 60 {lab=VDD}
C {devices/vdd.sym} 1110 60 0 0 {name=s44 lab=VDD}
N 1440 30 1440 10 {lab=VDD}
C {devices/vdd.sym} 1440 10 0 0 {name=s45 lab=VDD}
N 1440 60 1470 60 {lab=VDD}
C {devices/vdd.sym} 1470 60 0 0 {name=s46 lab=VDD}
N 1800 950 1800 970 {lab=0}
C {devices/gnd.sym} 1800 970 0 0 {name=s47 lab=0}
N 1800 920 1830 920 {lab=0}
C {devices/gnd.sym} 1830 920 0 0 {name=s48 lab=0}
N 1800 30 1800 10 {lab=VDD}
C {devices/vdd.sym} 1800 10 0 0 {name=s49 lab=VDD}
N 1800 60 1830 60 {lab=VDD}
C {devices/vdd.sym} 1830 60 0 0 {name=s50 lab=VDD}
N 2160 950 2160 970 {lab=0}
C {devices/gnd.sym} 2160 970 0 0 {name=s51 lab=0}
N 2160 920 2190 920 {lab=0}
C {devices/gnd.sym} 2190 920 0 0 {name=s52 lab=0}
N 2520 950 2520 970 {lab=0}
C {devices/gnd.sym} 2520 970 0 0 {name=s53 lab=0}
N 2520 920 2550 920 {lab=0}
C {devices/gnd.sym} 2550 920 0 0 {name=s54 lab=0}
N 4880 950 4880 970 {lab=0}
C {devices/gnd.sym} 4880 970 0 0 {name=s55 lab=0}
N 4880 920 4910 920 {lab=0}
C {devices/gnd.sym} 4910 920 0 0 {name=s56 lab=0}
N 4880 770 4910 770 {lab=0}
C {devices/gnd.sym} 4910 770 0 0 {name=s57 lab=0}
N 5080 620 5110 620 {lab=0}
C {devices/gnd.sym} 5110 620 0 0 {name=s58 lab=0}
N 5080 770 5110 770 {lab=0}
C {devices/gnd.sym} 5110 770 0 0 {name=s59 lab=0}
N 5080 950 5080 970 {lab=0}
C {devices/gnd.sym} 5080 970 0 0 {name=s60 lab=0}
N 5080 920 5110 920 {lab=0}
C {devices/gnd.sym} 5110 920 0 0 {name=s61 lab=0}
N 5640 950 5640 970 {lab=0}
C {devices/gnd.sym} 5640 970 0 0 {name=s62 lab=0}
N 5640 920 5670 920 {lab=0}
C {devices/gnd.sym} 5670 920 0 0 {name=s63 lab=0}
N 5640 770 5670 770 {lab=0}
C {devices/gnd.sym} 5670 770 0 0 {name=s64 lab=0}
N 5840 770 5870 770 {lab=0}
C {devices/gnd.sym} 5870 770 0 0 {name=s65 lab=0}
N 5840 950 5840 970 {lab=0}
C {devices/gnd.sym} 5840 970 0 0 {name=s66 lab=0}
N 5840 920 5870 920 {lab=0}
C {devices/gnd.sym} 5870 920 0 0 {name=s67 lab=0}
N 2880 950 2880 970 {lab=0}
C {devices/gnd.sym} 2880 970 0 0 {name=s68 lab=0}
N 2880 920 2910 920 {lab=0}
C {devices/gnd.sym} 2910 920 0 0 {name=s69 lab=0}
N 2880 770 2910 770 {lab=0}
C {devices/gnd.sym} 2910 770 0 0 {name=s70 lab=0}
N 3440 950 3440 970 {lab=0}
C {devices/gnd.sym} 3440 970 0 0 {name=s71 lab=0}
N 3440 920 3470 920 {lab=0}
C {devices/gnd.sym} 3470 920 0 0 {name=s72 lab=0}
N 2160 30 2160 10 {lab=VDD}
C {devices/vdd.sym} 2160 10 0 0 {name=s73 lab=VDD}
N 2160 60 2190 60 {lab=VDD}
C {devices/vdd.sym} 2190 60 0 0 {name=s74 lab=VDD}
N 2520 30 2520 10 {lab=VDD}
C {devices/vdd.sym} 2520 10 0 0 {name=s75 lab=VDD}
N 2520 60 2550 60 {lab=VDD}
C {devices/vdd.sym} 2550 60 0 0 {name=s76 lab=VDD}
N 4880 30 4880 10 {lab=VDD}
C {devices/vdd.sym} 4880 10 0 0 {name=s77 lab=VDD}
N 4880 60 4910 60 {lab=VDD}
C {devices/vdd.sym} 4910 60 0 0 {name=s78 lab=VDD}
N 4880 210 4910 210 {lab=VDD}
C {devices/vdd.sym} 4910 210 0 0 {name=s79 lab=VDD}
N 5280 210 5310 210 {lab=VDD}
C {devices/vdd.sym} 5310 210 0 0 {name=s80 lab=VDD}
N 5080 30 5080 10 {lab=VDD}
C {devices/vdd.sym} 5080 10 0 0 {name=s81 lab=VDD}
N 5080 60 5110 60 {lab=VDD}
C {devices/vdd.sym} 5110 60 0 0 {name=s82 lab=VDD}
N 5280 30 5280 10 {lab=VDD}
C {devices/vdd.sym} 5280 10 0 0 {name=s83 lab=VDD}
N 5280 60 5310 60 {lab=VDD}
C {devices/vdd.sym} 5310 60 0 0 {name=s84 lab=VDD}
N 5640 30 5640 10 {lab=VDD}
C {devices/vdd.sym} 5640 10 0 0 {name=s85 lab=VDD}
N 5640 60 5670 60 {lab=VDD}
C {devices/vdd.sym} 5670 60 0 0 {name=s86 lab=VDD}
N 5640 210 5670 210 {lab=VDD}
C {devices/vdd.sym} 5670 210 0 0 {name=s87 lab=VDD}
N 5840 210 5870 210 {lab=VDD}
C {devices/vdd.sym} 5870 210 0 0 {name=s88 lab=VDD}
N 5840 30 5840 10 {lab=VDD}
C {devices/vdd.sym} 5840 10 0 0 {name=s89 lab=VDD}
N 5840 60 5870 60 {lab=VDD}
C {devices/vdd.sym} 5870 60 0 0 {name=s90 lab=VDD}
N 2880 30 2880 10 {lab=VDD}
C {devices/vdd.sym} 2880 10 0 0 {name=s91 lab=VDD}
N 2880 60 2910 60 {lab=VDD}
C {devices/vdd.sym} 2910 60 0 0 {name=s92 lab=VDD}
N 3080 30 3080 10 {lab=VDD}
C {devices/vdd.sym} 3080 10 0 0 {name=s93 lab=VDD}
N 3080 60 3110 60 {lab=VDD}
C {devices/vdd.sym} 3110 60 0 0 {name=s94 lab=VDD}
N 3440 30 3440 10 {lab=VDD}
C {devices/vdd.sym} 3440 10 0 0 {name=s95 lab=VDD}
N 3440 60 3470 60 {lab=VDD}
C {devices/vdd.sym} 3470 60 0 0 {name=s96 lab=VDD}
N 3800 950 3800 970 {lab=0}
C {devices/gnd.sym} 3800 970 0 0 {name=s97 lab=0}
N 3800 920 3830 920 {lab=0}
C {devices/gnd.sym} 3830 920 0 0 {name=s98 lab=0}
N 3800 30 3800 10 {lab=VDD}
C {devices/vdd.sym} 3800 10 0 0 {name=s99 lab=VDD}
N 3800 60 3830 60 {lab=VDD}
C {devices/vdd.sym} 3830 60 0 0 {name=s100 lab=VDD}
N 4160 950 4160 970 {lab=0}
C {devices/gnd.sym} 4160 970 0 0 {name=s101 lab=0}
N 4160 920 4190 920 {lab=0}
C {devices/gnd.sym} 4190 920 0 0 {name=s102 lab=0}
N 4520 950 4520 970 {lab=0}
C {devices/gnd.sym} 4520 970 0 0 {name=s103 lab=0}
N 4520 920 4550 920 {lab=0}
C {devices/gnd.sym} 4550 920 0 0 {name=s104 lab=0}
N 8200 950 8200 970 {lab=0}
C {devices/gnd.sym} 8200 970 0 0 {name=s105 lab=0}
N 8200 920 8230 920 {lab=0}
C {devices/gnd.sym} 8230 920 0 0 {name=s106 lab=0}
N 8200 770 8230 770 {lab=0}
C {devices/gnd.sym} 8230 770 0 0 {name=s107 lab=0}
N 8400 620 8430 620 {lab=0}
C {devices/gnd.sym} 8430 620 0 0 {name=s108 lab=0}
N 8400 770 8430 770 {lab=0}
C {devices/gnd.sym} 8430 770 0 0 {name=s109 lab=0}
N 8400 950 8400 970 {lab=0}
C {devices/gnd.sym} 8400 970 0 0 {name=s110 lab=0}
N 8400 920 8430 920 {lab=0}
C {devices/gnd.sym} 8430 920 0 0 {name=s111 lab=0}
N 8960 950 8960 970 {lab=0}
C {devices/gnd.sym} 8960 970 0 0 {name=s112 lab=0}
N 8960 920 8990 920 {lab=0}
C {devices/gnd.sym} 8990 920 0 0 {name=s113 lab=0}
N 8960 770 8990 770 {lab=0}
C {devices/gnd.sym} 8990 770 0 0 {name=s114 lab=0}
N 9160 770 9190 770 {lab=0}
C {devices/gnd.sym} 9190 770 0 0 {name=s115 lab=0}
N 9160 950 9160 970 {lab=0}
C {devices/gnd.sym} 9160 970 0 0 {name=s116 lab=0}
N 9160 920 9190 920 {lab=0}
C {devices/gnd.sym} 9190 920 0 0 {name=s117 lab=0}
N 6200 950 6200 970 {lab=0}
C {devices/gnd.sym} 6200 970 0 0 {name=s118 lab=0}
N 6200 920 6230 920 {lab=0}
C {devices/gnd.sym} 6230 920 0 0 {name=s119 lab=0}
N 6200 770 6230 770 {lab=0}
C {devices/gnd.sym} 6230 770 0 0 {name=s120 lab=0}
N 6760 950 6760 970 {lab=0}
C {devices/gnd.sym} 6760 970 0 0 {name=s121 lab=0}
N 6760 920 6790 920 {lab=0}
C {devices/gnd.sym} 6790 920 0 0 {name=s122 lab=0}
N 4160 30 4160 10 {lab=VDD}
C {devices/vdd.sym} 4160 10 0 0 {name=s123 lab=VDD}
N 4160 60 4190 60 {lab=VDD}
C {devices/vdd.sym} 4190 60 0 0 {name=s124 lab=VDD}
N 4520 30 4520 10 {lab=VDD}
C {devices/vdd.sym} 4520 10 0 0 {name=s125 lab=VDD}
N 4520 60 4550 60 {lab=VDD}
C {devices/vdd.sym} 4550 60 0 0 {name=s126 lab=VDD}
N 8200 30 8200 10 {lab=VDD}
C {devices/vdd.sym} 8200 10 0 0 {name=s127 lab=VDD}
N 8200 60 8230 60 {lab=VDD}
C {devices/vdd.sym} 8230 60 0 0 {name=s128 lab=VDD}
N 8200 210 8230 210 {lab=VDD}
C {devices/vdd.sym} 8230 210 0 0 {name=s129 lab=VDD}
N 8600 210 8630 210 {lab=VDD}
C {devices/vdd.sym} 8630 210 0 0 {name=s130 lab=VDD}
N 8400 30 8400 10 {lab=VDD}
C {devices/vdd.sym} 8400 10 0 0 {name=s131 lab=VDD}
N 8400 60 8430 60 {lab=VDD}
C {devices/vdd.sym} 8430 60 0 0 {name=s132 lab=VDD}
N 8600 30 8600 10 {lab=VDD}
C {devices/vdd.sym} 8600 10 0 0 {name=s133 lab=VDD}
N 8600 60 8630 60 {lab=VDD}
C {devices/vdd.sym} 8630 60 0 0 {name=s134 lab=VDD}
N 8960 30 8960 10 {lab=VDD}
C {devices/vdd.sym} 8960 10 0 0 {name=s135 lab=VDD}
N 8960 60 8990 60 {lab=VDD}
C {devices/vdd.sym} 8990 60 0 0 {name=s136 lab=VDD}
N 8960 210 8990 210 {lab=VDD}
C {devices/vdd.sym} 8990 210 0 0 {name=s137 lab=VDD}
N 9160 210 9190 210 {lab=VDD}
C {devices/vdd.sym} 9190 210 0 0 {name=s138 lab=VDD}
N 9160 30 9160 10 {lab=VDD}
C {devices/vdd.sym} 9160 10 0 0 {name=s139 lab=VDD}
N 9160 60 9190 60 {lab=VDD}
C {devices/vdd.sym} 9190 60 0 0 {name=s140 lab=VDD}
N 6200 30 6200 10 {lab=VDD}
C {devices/vdd.sym} 6200 10 0 0 {name=s141 lab=VDD}
N 6200 60 6230 60 {lab=VDD}
C {devices/vdd.sym} 6230 60 0 0 {name=s142 lab=VDD}
N 6400 30 6400 10 {lab=VDD}
C {devices/vdd.sym} 6400 10 0 0 {name=s143 lab=VDD}
N 6400 60 6430 60 {lab=VDD}
C {devices/vdd.sym} 6430 60 0 0 {name=s144 lab=VDD}
N 6760 30 6760 10 {lab=VDD}
C {devices/vdd.sym} 6760 10 0 0 {name=s145 lab=VDD}
N 6760 60 6790 60 {lab=VDD}
C {devices/vdd.sym} 6790 60 0 0 {name=s146 lab=VDD}
N 7120 950 7120 970 {lab=0}
C {devices/gnd.sym} 7120 970 0 0 {name=s147 lab=0}
N 7120 920 7150 920 {lab=0}
C {devices/gnd.sym} 7150 920 0 0 {name=s148 lab=0}
N 7120 30 7120 10 {lab=VDD}
C {devices/vdd.sym} 7120 10 0 0 {name=s149 lab=VDD}
N 7120 60 7150 60 {lab=VDD}
C {devices/vdd.sym} 7150 60 0 0 {name=s150 lab=VDD}
N 7480 950 7480 970 {lab=0}
C {devices/gnd.sym} 7480 970 0 0 {name=s151 lab=0}
N 7480 920 7510 920 {lab=0}
C {devices/gnd.sym} 7510 920 0 0 {name=s152 lab=0}
N 7840 950 7840 970 {lab=0}
C {devices/gnd.sym} 7840 970 0 0 {name=s153 lab=0}
N 7840 920 7870 920 {lab=0}
C {devices/gnd.sym} 7870 920 0 0 {name=s154 lab=0}
N 11520 950 11520 970 {lab=0}
C {devices/gnd.sym} 11520 970 0 0 {name=s155 lab=0}
N 11520 920 11550 920 {lab=0}
C {devices/gnd.sym} 11550 920 0 0 {name=s156 lab=0}
N 11520 770 11550 770 {lab=0}
C {devices/gnd.sym} 11550 770 0 0 {name=s157 lab=0}
N 11720 620 11750 620 {lab=0}
C {devices/gnd.sym} 11750 620 0 0 {name=s158 lab=0}
N 11720 770 11750 770 {lab=0}
C {devices/gnd.sym} 11750 770 0 0 {name=s159 lab=0}
N 11720 950 11720 970 {lab=0}
C {devices/gnd.sym} 11720 970 0 0 {name=s160 lab=0}
N 11720 920 11750 920 {lab=0}
C {devices/gnd.sym} 11750 920 0 0 {name=s161 lab=0}
N 12280 950 12280 970 {lab=0}
C {devices/gnd.sym} 12280 970 0 0 {name=s162 lab=0}
N 12280 920 12310 920 {lab=0}
C {devices/gnd.sym} 12310 920 0 0 {name=s163 lab=0}
N 12280 770 12310 770 {lab=0}
C {devices/gnd.sym} 12310 770 0 0 {name=s164 lab=0}
N 12480 770 12510 770 {lab=0}
C {devices/gnd.sym} 12510 770 0 0 {name=s165 lab=0}
N 12480 950 12480 970 {lab=0}
C {devices/gnd.sym} 12480 970 0 0 {name=s166 lab=0}
N 12480 920 12510 920 {lab=0}
C {devices/gnd.sym} 12510 920 0 0 {name=s167 lab=0}
N 9520 950 9520 970 {lab=0}
C {devices/gnd.sym} 9520 970 0 0 {name=s168 lab=0}
N 9520 920 9550 920 {lab=0}
C {devices/gnd.sym} 9550 920 0 0 {name=s169 lab=0}
N 9520 770 9550 770 {lab=0}
C {devices/gnd.sym} 9550 770 0 0 {name=s170 lab=0}
N 10080 950 10080 970 {lab=0}
C {devices/gnd.sym} 10080 970 0 0 {name=s171 lab=0}
N 10080 920 10110 920 {lab=0}
C {devices/gnd.sym} 10110 920 0 0 {name=s172 lab=0}
N 7480 30 7480 10 {lab=VDD}
C {devices/vdd.sym} 7480 10 0 0 {name=s173 lab=VDD}
N 7480 60 7510 60 {lab=VDD}
C {devices/vdd.sym} 7510 60 0 0 {name=s174 lab=VDD}
N 7840 30 7840 10 {lab=VDD}
C {devices/vdd.sym} 7840 10 0 0 {name=s175 lab=VDD}
N 7840 60 7870 60 {lab=VDD}
C {devices/vdd.sym} 7870 60 0 0 {name=s176 lab=VDD}
N 11520 30 11520 10 {lab=VDD}
C {devices/vdd.sym} 11520 10 0 0 {name=s177 lab=VDD}
N 11520 60 11550 60 {lab=VDD}
C {devices/vdd.sym} 11550 60 0 0 {name=s178 lab=VDD}
N 11520 210 11550 210 {lab=VDD}
C {devices/vdd.sym} 11550 210 0 0 {name=s179 lab=VDD}
N 11920 210 11950 210 {lab=VDD}
C {devices/vdd.sym} 11950 210 0 0 {name=s180 lab=VDD}
N 11720 30 11720 10 {lab=VDD}
C {devices/vdd.sym} 11720 10 0 0 {name=s181 lab=VDD}
N 11720 60 11750 60 {lab=VDD}
C {devices/vdd.sym} 11750 60 0 0 {name=s182 lab=VDD}
N 11920 30 11920 10 {lab=VDD}
C {devices/vdd.sym} 11920 10 0 0 {name=s183 lab=VDD}
N 11920 60 11950 60 {lab=VDD}
C {devices/vdd.sym} 11950 60 0 0 {name=s184 lab=VDD}
N 12280 30 12280 10 {lab=VDD}
C {devices/vdd.sym} 12280 10 0 0 {name=s185 lab=VDD}
N 12280 60 12310 60 {lab=VDD}
C {devices/vdd.sym} 12310 60 0 0 {name=s186 lab=VDD}
N 12280 210 12310 210 {lab=VDD}
C {devices/vdd.sym} 12310 210 0 0 {name=s187 lab=VDD}
N 12480 210 12510 210 {lab=VDD}
C {devices/vdd.sym} 12510 210 0 0 {name=s188 lab=VDD}
N 12480 30 12480 10 {lab=VDD}
C {devices/vdd.sym} 12480 10 0 0 {name=s189 lab=VDD}
N 12480 60 12510 60 {lab=VDD}
C {devices/vdd.sym} 12510 60 0 0 {name=s190 lab=VDD}
N 9520 30 9520 10 {lab=VDD}
C {devices/vdd.sym} 9520 10 0 0 {name=s191 lab=VDD}
N 9520 60 9550 60 {lab=VDD}
C {devices/vdd.sym} 9550 60 0 0 {name=s192 lab=VDD}
N 9720 30 9720 10 {lab=VDD}
C {devices/vdd.sym} 9720 10 0 0 {name=s193 lab=VDD}
N 9720 60 9750 60 {lab=VDD}
C {devices/vdd.sym} 9750 60 0 0 {name=s194 lab=VDD}
N 10080 30 10080 10 {lab=VDD}
C {devices/vdd.sym} 10080 10 0 0 {name=s195 lab=VDD}
N 10080 60 10110 60 {lab=VDD}
C {devices/vdd.sym} 10110 60 0 0 {name=s196 lab=VDD}
N 10440 950 10440 970 {lab=0}
C {devices/gnd.sym} 10440 970 0 0 {name=s197 lab=0}
N 10440 920 10470 920 {lab=0}
C {devices/gnd.sym} 10470 920 0 0 {name=s198 lab=0}
N 10440 30 10440 10 {lab=VDD}
C {devices/vdd.sym} 10440 10 0 0 {name=s199 lab=VDD}
N 10440 60 10470 60 {lab=VDD}
C {devices/vdd.sym} 10470 60 0 0 {name=s200 lab=VDD}
N 10800 950 10800 970 {lab=0}
C {devices/gnd.sym} 10800 970 0 0 {name=s201 lab=0}
N 10800 920 10830 920 {lab=0}
C {devices/gnd.sym} 10830 920 0 0 {name=s202 lab=0}
N 11160 950 11160 970 {lab=0}
C {devices/gnd.sym} 11160 970 0 0 {name=s203 lab=0}
N 11160 920 11190 920 {lab=0}
C {devices/gnd.sym} 11190 920 0 0 {name=s204 lab=0}
N 14840 950 14840 970 {lab=0}
C {devices/gnd.sym} 14840 970 0 0 {name=s205 lab=0}
N 14840 920 14870 920 {lab=0}
C {devices/gnd.sym} 14870 920 0 0 {name=s206 lab=0}
N 14840 770 14870 770 {lab=0}
C {devices/gnd.sym} 14870 770 0 0 {name=s207 lab=0}
N 15040 620 15070 620 {lab=0}
C {devices/gnd.sym} 15070 620 0 0 {name=s208 lab=0}
N 15040 770 15070 770 {lab=0}
C {devices/gnd.sym} 15070 770 0 0 {name=s209 lab=0}
N 15040 950 15040 970 {lab=0}
C {devices/gnd.sym} 15040 970 0 0 {name=s210 lab=0}
N 15040 920 15070 920 {lab=0}
C {devices/gnd.sym} 15070 920 0 0 {name=s211 lab=0}
N 15600 950 15600 970 {lab=0}
C {devices/gnd.sym} 15600 970 0 0 {name=s212 lab=0}
N 15600 920 15630 920 {lab=0}
C {devices/gnd.sym} 15630 920 0 0 {name=s213 lab=0}
N 15600 770 15630 770 {lab=0}
C {devices/gnd.sym} 15630 770 0 0 {name=s214 lab=0}
N 15800 770 15830 770 {lab=0}
C {devices/gnd.sym} 15830 770 0 0 {name=s215 lab=0}
N 15800 950 15800 970 {lab=0}
C {devices/gnd.sym} 15800 970 0 0 {name=s216 lab=0}
N 15800 920 15830 920 {lab=0}
C {devices/gnd.sym} 15830 920 0 0 {name=s217 lab=0}
N 12840 950 12840 970 {lab=0}
C {devices/gnd.sym} 12840 970 0 0 {name=s218 lab=0}
N 12840 920 12870 920 {lab=0}
C {devices/gnd.sym} 12870 920 0 0 {name=s219 lab=0}
N 12840 770 12870 770 {lab=0}
C {devices/gnd.sym} 12870 770 0 0 {name=s220 lab=0}
N 13400 950 13400 970 {lab=0}
C {devices/gnd.sym} 13400 970 0 0 {name=s221 lab=0}
N 13400 920 13430 920 {lab=0}
C {devices/gnd.sym} 13430 920 0 0 {name=s222 lab=0}
N 10800 30 10800 10 {lab=VDD}
C {devices/vdd.sym} 10800 10 0 0 {name=s223 lab=VDD}
N 10800 60 10830 60 {lab=VDD}
C {devices/vdd.sym} 10830 60 0 0 {name=s224 lab=VDD}
N 11160 30 11160 10 {lab=VDD}
C {devices/vdd.sym} 11160 10 0 0 {name=s225 lab=VDD}
N 11160 60 11190 60 {lab=VDD}
C {devices/vdd.sym} 11190 60 0 0 {name=s226 lab=VDD}
N 14840 30 14840 10 {lab=VDD}
C {devices/vdd.sym} 14840 10 0 0 {name=s227 lab=VDD}
N 14840 60 14870 60 {lab=VDD}
C {devices/vdd.sym} 14870 60 0 0 {name=s228 lab=VDD}
N 14840 210 14870 210 {lab=VDD}
C {devices/vdd.sym} 14870 210 0 0 {name=s229 lab=VDD}
N 15240 210 15270 210 {lab=VDD}
C {devices/vdd.sym} 15270 210 0 0 {name=s230 lab=VDD}
N 15040 30 15040 10 {lab=VDD}
C {devices/vdd.sym} 15040 10 0 0 {name=s231 lab=VDD}
N 15040 60 15070 60 {lab=VDD}
C {devices/vdd.sym} 15070 60 0 0 {name=s232 lab=VDD}
N 15240 30 15240 10 {lab=VDD}
C {devices/vdd.sym} 15240 10 0 0 {name=s233 lab=VDD}
N 15240 60 15270 60 {lab=VDD}
C {devices/vdd.sym} 15270 60 0 0 {name=s234 lab=VDD}
N 15600 30 15600 10 {lab=VDD}
C {devices/vdd.sym} 15600 10 0 0 {name=s235 lab=VDD}
N 15600 60 15630 60 {lab=VDD}
C {devices/vdd.sym} 15630 60 0 0 {name=s236 lab=VDD}
N 15600 210 15630 210 {lab=VDD}
C {devices/vdd.sym} 15630 210 0 0 {name=s237 lab=VDD}
N 15800 210 15830 210 {lab=VDD}
C {devices/vdd.sym} 15830 210 0 0 {name=s238 lab=VDD}
N 15800 30 15800 10 {lab=VDD}
C {devices/vdd.sym} 15800 10 0 0 {name=s239 lab=VDD}
N 15800 60 15830 60 {lab=VDD}
C {devices/vdd.sym} 15830 60 0 0 {name=s240 lab=VDD}
N 12840 30 12840 10 {lab=VDD}
C {devices/vdd.sym} 12840 10 0 0 {name=s241 lab=VDD}
N 12840 60 12870 60 {lab=VDD}
C {devices/vdd.sym} 12870 60 0 0 {name=s242 lab=VDD}
N 13040 30 13040 10 {lab=VDD}
C {devices/vdd.sym} 13040 10 0 0 {name=s243 lab=VDD}
N 13040 60 13070 60 {lab=VDD}
C {devices/vdd.sym} 13070 60 0 0 {name=s244 lab=VDD}
N 13400 30 13400 10 {lab=VDD}
C {devices/vdd.sym} 13400 10 0 0 {name=s245 lab=VDD}
N 13400 60 13430 60 {lab=VDD}
C {devices/vdd.sym} 13430 60 0 0 {name=s246 lab=VDD}
N 13760 950 13760 970 {lab=0}
C {devices/gnd.sym} 13760 970 0 0 {name=s247 lab=0}
N 13760 920 13790 920 {lab=0}
C {devices/gnd.sym} 13790 920 0 0 {name=s248 lab=0}
N 13760 30 13760 10 {lab=VDD}
C {devices/vdd.sym} 13760 10 0 0 {name=s249 lab=VDD}
N 13760 60 13790 60 {lab=VDD}
C {devices/vdd.sym} 13790 60 0 0 {name=s250 lab=VDD}
N 14120 950 14120 970 {lab=0}
C {devices/gnd.sym} 14120 970 0 0 {name=s251 lab=0}
N 14120 920 14150 920 {lab=0}
C {devices/gnd.sym} 14150 920 0 0 {name=s252 lab=0}
N 14480 950 14480 970 {lab=0}
C {devices/gnd.sym} 14480 970 0 0 {name=s253 lab=0}
N 14480 920 14510 920 {lab=0}
C {devices/gnd.sym} 14510 920 0 0 {name=s254 lab=0}
N 17440 950 17440 970 {lab=0}
C {devices/gnd.sym} 17440 970 0 0 {name=s255 lab=0}
N 17440 920 17470 920 {lab=0}
C {devices/gnd.sym} 17470 920 0 0 {name=s256 lab=0}
N 17440 770 17470 770 {lab=0}
C {devices/gnd.sym} 17470 770 0 0 {name=s257 lab=0}
N 17640 620 17670 620 {lab=0}
C {devices/gnd.sym} 17670 620 0 0 {name=s258 lab=0}
N 17640 770 17670 770 {lab=0}
C {devices/gnd.sym} 17670 770 0 0 {name=s259 lab=0}
N 17640 950 17640 970 {lab=0}
C {devices/gnd.sym} 17640 970 0 0 {name=s260 lab=0}
N 17640 920 17670 920 {lab=0}
C {devices/gnd.sym} 17670 920 0 0 {name=s261 lab=0}
N 18200 950 18200 970 {lab=0}
C {devices/gnd.sym} 18200 970 0 0 {name=s262 lab=0}
N 18200 920 18230 920 {lab=0}
C {devices/gnd.sym} 18230 920 0 0 {name=s263 lab=0}
N 18200 770 18230 770 {lab=0}
C {devices/gnd.sym} 18230 770 0 0 {name=s264 lab=0}
N 18400 770 18430 770 {lab=0}
C {devices/gnd.sym} 18430 770 0 0 {name=s265 lab=0}
N 18400 950 18400 970 {lab=0}
C {devices/gnd.sym} 18400 970 0 0 {name=s266 lab=0}
N 18400 920 18430 920 {lab=0}
C {devices/gnd.sym} 18430 920 0 0 {name=s267 lab=0}
N 16160 950 16160 970 {lab=0}
C {devices/gnd.sym} 16160 970 0 0 {name=s268 lab=0}
N 16160 920 16190 920 {lab=0}
C {devices/gnd.sym} 16190 920 0 0 {name=s269 lab=0}
N 16160 770 16190 770 {lab=0}
C {devices/gnd.sym} 16190 770 0 0 {name=s270 lab=0}
N 16720 950 16720 970 {lab=0}
C {devices/gnd.sym} 16720 970 0 0 {name=s271 lab=0}
N 16720 920 16750 920 {lab=0}
C {devices/gnd.sym} 16750 920 0 0 {name=s272 lab=0}
N 14120 30 14120 10 {lab=VDD}
C {devices/vdd.sym} 14120 10 0 0 {name=s273 lab=VDD}
N 14120 60 14150 60 {lab=VDD}
C {devices/vdd.sym} 14150 60 0 0 {name=s274 lab=VDD}
N 14480 30 14480 10 {lab=VDD}
C {devices/vdd.sym} 14480 10 0 0 {name=s275 lab=VDD}
N 14480 60 14510 60 {lab=VDD}
C {devices/vdd.sym} 14510 60 0 0 {name=s276 lab=VDD}
N 17440 30 17440 10 {lab=VDD}
C {devices/vdd.sym} 17440 10 0 0 {name=s277 lab=VDD}
N 17440 60 17470 60 {lab=VDD}
C {devices/vdd.sym} 17470 60 0 0 {name=s278 lab=VDD}
N 17440 210 17470 210 {lab=VDD}
C {devices/vdd.sym} 17470 210 0 0 {name=s279 lab=VDD}
N 17840 210 17870 210 {lab=VDD}
C {devices/vdd.sym} 17870 210 0 0 {name=s280 lab=VDD}
N 17640 30 17640 10 {lab=VDD}
C {devices/vdd.sym} 17640 10 0 0 {name=s281 lab=VDD}
N 17640 60 17670 60 {lab=VDD}
C {devices/vdd.sym} 17670 60 0 0 {name=s282 lab=VDD}
N 17840 30 17840 10 {lab=VDD}
C {devices/vdd.sym} 17840 10 0 0 {name=s283 lab=VDD}
N 17840 60 17870 60 {lab=VDD}
C {devices/vdd.sym} 17870 60 0 0 {name=s284 lab=VDD}
N 18200 30 18200 10 {lab=VDD}
C {devices/vdd.sym} 18200 10 0 0 {name=s285 lab=VDD}
N 18200 60 18230 60 {lab=VDD}
C {devices/vdd.sym} 18230 60 0 0 {name=s286 lab=VDD}
N 18200 210 18230 210 {lab=VDD}
C {devices/vdd.sym} 18230 210 0 0 {name=s287 lab=VDD}
N 18400 210 18430 210 {lab=VDD}
C {devices/vdd.sym} 18430 210 0 0 {name=s288 lab=VDD}
N 18400 30 18400 10 {lab=VDD}
C {devices/vdd.sym} 18400 10 0 0 {name=s289 lab=VDD}
N 18400 60 18430 60 {lab=VDD}
C {devices/vdd.sym} 18430 60 0 0 {name=s290 lab=VDD}
N 16160 30 16160 10 {lab=VDD}
C {devices/vdd.sym} 16160 10 0 0 {name=s291 lab=VDD}
N 16160 60 16190 60 {lab=VDD}
C {devices/vdd.sym} 16190 60 0 0 {name=s292 lab=VDD}
N 16360 30 16360 10 {lab=VDD}
C {devices/vdd.sym} 16360 10 0 0 {name=s293 lab=VDD}
N 16360 60 16390 60 {lab=VDD}
C {devices/vdd.sym} 16390 60 0 0 {name=s294 lab=VDD}
N 16720 30 16720 10 {lab=VDD}
C {devices/vdd.sym} 16720 10 0 0 {name=s295 lab=VDD}
N 16720 60 16750 60 {lab=VDD}
C {devices/vdd.sym} 16750 60 0 0 {name=s296 lab=VDD}
N 17080 950 17080 970 {lab=0}
C {devices/gnd.sym} 17080 970 0 0 {name=s297 lab=0}
N 17080 920 17110 920 {lab=0}
C {devices/gnd.sym} 17110 920 0 0 {name=s298 lab=0}
N 17080 30 17080 10 {lab=VDD}
C {devices/vdd.sym} 17080 10 0 0 {name=s299 lab=VDD}
N 17080 60 17110 60 {lab=VDD}
C {devices/vdd.sym} 17110 60 0 0 {name=s300 lab=VDD}
N 50680 950 50680 970 {lab=0}
C {devices/gnd.sym} 50680 970 0 0 {name=s301 lab=0}
N 50680 920 50710 920 {lab=0}
C {devices/gnd.sym} 50710 920 0 0 {name=s302 lab=0}
N 51040 950 51040 970 {lab=0}
C {devices/gnd.sym} 51040 970 0 0 {name=s303 lab=0}
N 51040 920 51070 920 {lab=0}
C {devices/gnd.sym} 51070 920 0 0 {name=s304 lab=0}
N 51400 950 51400 970 {lab=0}
C {devices/gnd.sym} 51400 970 0 0 {name=s305 lab=0}
N 51400 920 51430 920 {lab=0}
C {devices/gnd.sym} 51430 920 0 0 {name=s306 lab=0}
N 51400 770 51430 770 {lab=0}
C {devices/gnd.sym} 51430 770 0 0 {name=s307 lab=0}
N 51600 620 51630 620 {lab=0}
C {devices/gnd.sym} 51630 620 0 0 {name=s308 lab=0}
N 51600 770 51630 770 {lab=0}
C {devices/gnd.sym} 51630 770 0 0 {name=s309 lab=0}
N 51600 950 51600 970 {lab=0}
C {devices/gnd.sym} 51600 970 0 0 {name=s310 lab=0}
N 51600 920 51630 920 {lab=0}
C {devices/gnd.sym} 51630 920 0 0 {name=s311 lab=0}
N 52160 950 52160 970 {lab=0}
C {devices/gnd.sym} 52160 970 0 0 {name=s312 lab=0}
N 52160 920 52190 920 {lab=0}
C {devices/gnd.sym} 52190 920 0 0 {name=s313 lab=0}
N 52160 770 52190 770 {lab=0}
C {devices/gnd.sym} 52190 770 0 0 {name=s314 lab=0}
N 52360 770 52390 770 {lab=0}
C {devices/gnd.sym} 52390 770 0 0 {name=s315 lab=0}
N 52360 950 52360 970 {lab=0}
C {devices/gnd.sym} 52360 970 0 0 {name=s316 lab=0}
N 52360 920 52390 920 {lab=0}
C {devices/gnd.sym} 52390 920 0 0 {name=s317 lab=0}
N 18760 950 18760 970 {lab=0}
C {devices/gnd.sym} 18760 970 0 0 {name=s318 lab=0}
N 18760 920 18790 920 {lab=0}
C {devices/gnd.sym} 18790 920 0 0 {name=s319 lab=0}
N 18760 770 18790 770 {lab=0}
C {devices/gnd.sym} 18790 770 0 0 {name=s320 lab=0}
N 19320 950 19320 970 {lab=0}
C {devices/gnd.sym} 19320 970 0 0 {name=s321 lab=0}
N 19320 920 19350 920 {lab=0}
C {devices/gnd.sym} 19350 920 0 0 {name=s322 lab=0}
N 50680 30 50680 10 {lab=VDD}
C {devices/vdd.sym} 50680 10 0 0 {name=s323 lab=VDD}
N 50680 60 50710 60 {lab=VDD}
C {devices/vdd.sym} 50710 60 0 0 {name=s324 lab=VDD}
N 51040 30 51040 10 {lab=VDD}
C {devices/vdd.sym} 51040 10 0 0 {name=s325 lab=VDD}
N 51040 60 51070 60 {lab=VDD}
C {devices/vdd.sym} 51070 60 0 0 {name=s326 lab=VDD}
N 51400 30 51400 10 {lab=VDD}
C {devices/vdd.sym} 51400 10 0 0 {name=s327 lab=VDD}
N 51400 60 51430 60 {lab=VDD}
C {devices/vdd.sym} 51430 60 0 0 {name=s328 lab=VDD}
N 51400 210 51430 210 {lab=VDD}
C {devices/vdd.sym} 51430 210 0 0 {name=s329 lab=VDD}
N 51800 210 51830 210 {lab=VDD}
C {devices/vdd.sym} 51830 210 0 0 {name=s330 lab=VDD}
N 51600 30 51600 10 {lab=VDD}
C {devices/vdd.sym} 51600 10 0 0 {name=s331 lab=VDD}
N 51600 60 51630 60 {lab=VDD}
C {devices/vdd.sym} 51630 60 0 0 {name=s332 lab=VDD}
N 51800 30 51800 10 {lab=VDD}
C {devices/vdd.sym} 51800 10 0 0 {name=s333 lab=VDD}
N 51800 60 51830 60 {lab=VDD}
C {devices/vdd.sym} 51830 60 0 0 {name=s334 lab=VDD}
N 52160 30 52160 10 {lab=VDD}
C {devices/vdd.sym} 52160 10 0 0 {name=s335 lab=VDD}
N 52160 60 52190 60 {lab=VDD}
C {devices/vdd.sym} 52190 60 0 0 {name=s336 lab=VDD}
N 52160 210 52190 210 {lab=VDD}
C {devices/vdd.sym} 52190 210 0 0 {name=s337 lab=VDD}
N 52360 210 52390 210 {lab=VDD}
C {devices/vdd.sym} 52390 210 0 0 {name=s338 lab=VDD}
N 52360 30 52360 10 {lab=VDD}
C {devices/vdd.sym} 52360 10 0 0 {name=s339 lab=VDD}
N 52360 60 52390 60 {lab=VDD}
C {devices/vdd.sym} 52390 60 0 0 {name=s340 lab=VDD}
N 18760 30 18760 10 {lab=VDD}
C {devices/vdd.sym} 18760 10 0 0 {name=s341 lab=VDD}
N 18760 60 18790 60 {lab=VDD}
C {devices/vdd.sym} 18790 60 0 0 {name=s342 lab=VDD}
N 18960 30 18960 10 {lab=VDD}
C {devices/vdd.sym} 18960 10 0 0 {name=s343 lab=VDD}
N 18960 60 18990 60 {lab=VDD}
C {devices/vdd.sym} 18990 60 0 0 {name=s344 lab=VDD}
N 19320 30 19320 10 {lab=VDD}
C {devices/vdd.sym} 19320 10 0 0 {name=s345 lab=VDD}
N 19320 60 19350 60 {lab=VDD}
C {devices/vdd.sym} 19350 60 0 0 {name=s346 lab=VDD}
N 19680 950 19680 970 {lab=0}
C {devices/gnd.sym} 19680 970 0 0 {name=s347 lab=0}
N 19680 920 19710 920 {lab=0}
C {devices/gnd.sym} 19710 920 0 0 {name=s348 lab=0}
N 19680 30 19680 10 {lab=VDD}
C {devices/vdd.sym} 19680 10 0 0 {name=s349 lab=VDD}
N 19680 60 19710 60 {lab=VDD}
C {devices/vdd.sym} 19710 60 0 0 {name=s350 lab=VDD}
N 20040 950 20040 970 {lab=0}
C {devices/gnd.sym} 20040 970 0 0 {name=s351 lab=0}
N 20040 920 20070 920 {lab=0}
C {devices/gnd.sym} 20070 920 0 0 {name=s352 lab=0}
N 20400 950 20400 970 {lab=0}
C {devices/gnd.sym} 20400 970 0 0 {name=s353 lab=0}
N 20400 920 20430 920 {lab=0}
C {devices/gnd.sym} 20430 920 0 0 {name=s354 lab=0}
N 22760 950 22760 970 {lab=0}
C {devices/gnd.sym} 22760 970 0 0 {name=s355 lab=0}
N 22760 920 22790 920 {lab=0}
C {devices/gnd.sym} 22790 920 0 0 {name=s356 lab=0}
N 22760 770 22790 770 {lab=0}
C {devices/gnd.sym} 22790 770 0 0 {name=s357 lab=0}
N 22960 620 22990 620 {lab=0}
C {devices/gnd.sym} 22990 620 0 0 {name=s358 lab=0}
N 22960 770 22990 770 {lab=0}
C {devices/gnd.sym} 22990 770 0 0 {name=s359 lab=0}
N 22960 950 22960 970 {lab=0}
C {devices/gnd.sym} 22960 970 0 0 {name=s360 lab=0}
N 22960 920 22990 920 {lab=0}
C {devices/gnd.sym} 22990 920 0 0 {name=s361 lab=0}
N 23520 950 23520 970 {lab=0}
C {devices/gnd.sym} 23520 970 0 0 {name=s362 lab=0}
N 23520 920 23550 920 {lab=0}
C {devices/gnd.sym} 23550 920 0 0 {name=s363 lab=0}
N 23520 770 23550 770 {lab=0}
C {devices/gnd.sym} 23550 770 0 0 {name=s364 lab=0}
N 23720 770 23750 770 {lab=0}
C {devices/gnd.sym} 23750 770 0 0 {name=s365 lab=0}
N 23720 950 23720 970 {lab=0}
C {devices/gnd.sym} 23720 970 0 0 {name=s366 lab=0}
N 23720 920 23750 920 {lab=0}
C {devices/gnd.sym} 23750 920 0 0 {name=s367 lab=0}
N 20760 950 20760 970 {lab=0}
C {devices/gnd.sym} 20760 970 0 0 {name=s368 lab=0}
N 20760 920 20790 920 {lab=0}
C {devices/gnd.sym} 20790 920 0 0 {name=s369 lab=0}
N 20760 770 20790 770 {lab=0}
C {devices/gnd.sym} 20790 770 0 0 {name=s370 lab=0}
N 21320 950 21320 970 {lab=0}
C {devices/gnd.sym} 21320 970 0 0 {name=s371 lab=0}
N 21320 920 21350 920 {lab=0}
C {devices/gnd.sym} 21350 920 0 0 {name=s372 lab=0}
N 20040 30 20040 10 {lab=VDD}
C {devices/vdd.sym} 20040 10 0 0 {name=s373 lab=VDD}
N 20040 60 20070 60 {lab=VDD}
C {devices/vdd.sym} 20070 60 0 0 {name=s374 lab=VDD}
N 20400 30 20400 10 {lab=VDD}
C {devices/vdd.sym} 20400 10 0 0 {name=s375 lab=VDD}
N 20400 60 20430 60 {lab=VDD}
C {devices/vdd.sym} 20430 60 0 0 {name=s376 lab=VDD}
N 22760 30 22760 10 {lab=VDD}
C {devices/vdd.sym} 22760 10 0 0 {name=s377 lab=VDD}
N 22760 60 22790 60 {lab=VDD}
C {devices/vdd.sym} 22790 60 0 0 {name=s378 lab=VDD}
N 22760 210 22790 210 {lab=VDD}
C {devices/vdd.sym} 22790 210 0 0 {name=s379 lab=VDD}
N 23160 210 23190 210 {lab=VDD}
C {devices/vdd.sym} 23190 210 0 0 {name=s380 lab=VDD}
N 22960 30 22960 10 {lab=VDD}
C {devices/vdd.sym} 22960 10 0 0 {name=s381 lab=VDD}
N 22960 60 22990 60 {lab=VDD}
C {devices/vdd.sym} 22990 60 0 0 {name=s382 lab=VDD}
N 23160 30 23160 10 {lab=VDD}
C {devices/vdd.sym} 23160 10 0 0 {name=s383 lab=VDD}
N 23160 60 23190 60 {lab=VDD}
C {devices/vdd.sym} 23190 60 0 0 {name=s384 lab=VDD}
N 23520 30 23520 10 {lab=VDD}
C {devices/vdd.sym} 23520 10 0 0 {name=s385 lab=VDD}
N 23520 60 23550 60 {lab=VDD}
C {devices/vdd.sym} 23550 60 0 0 {name=s386 lab=VDD}
N 23520 210 23550 210 {lab=VDD}
C {devices/vdd.sym} 23550 210 0 0 {name=s387 lab=VDD}
N 23720 210 23750 210 {lab=VDD}
C {devices/vdd.sym} 23750 210 0 0 {name=s388 lab=VDD}
N 23720 30 23720 10 {lab=VDD}
C {devices/vdd.sym} 23720 10 0 0 {name=s389 lab=VDD}
N 23720 60 23750 60 {lab=VDD}
C {devices/vdd.sym} 23750 60 0 0 {name=s390 lab=VDD}
N 20760 30 20760 10 {lab=VDD}
C {devices/vdd.sym} 20760 10 0 0 {name=s391 lab=VDD}
N 20760 60 20790 60 {lab=VDD}
C {devices/vdd.sym} 20790 60 0 0 {name=s392 lab=VDD}
N 20960 30 20960 10 {lab=VDD}
C {devices/vdd.sym} 20960 10 0 0 {name=s393 lab=VDD}
N 20960 60 20990 60 {lab=VDD}
C {devices/vdd.sym} 20990 60 0 0 {name=s394 lab=VDD}
N 21320 30 21320 10 {lab=VDD}
C {devices/vdd.sym} 21320 10 0 0 {name=s395 lab=VDD}
N 21320 60 21350 60 {lab=VDD}
C {devices/vdd.sym} 21350 60 0 0 {name=s396 lab=VDD}
N 21680 950 21680 970 {lab=0}
C {devices/gnd.sym} 21680 970 0 0 {name=s397 lab=0}
N 21680 920 21710 920 {lab=0}
C {devices/gnd.sym} 21710 920 0 0 {name=s398 lab=0}
N 21680 30 21680 10 {lab=VDD}
C {devices/vdd.sym} 21680 10 0 0 {name=s399 lab=VDD}
N 21680 60 21710 60 {lab=VDD}
C {devices/vdd.sym} 21710 60 0 0 {name=s400 lab=VDD}
N 22040 950 22040 970 {lab=0}
C {devices/gnd.sym} 22040 970 0 0 {name=s401 lab=0}
N 22040 920 22070 920 {lab=0}
C {devices/gnd.sym} 22070 920 0 0 {name=s402 lab=0}
N 22400 950 22400 970 {lab=0}
C {devices/gnd.sym} 22400 970 0 0 {name=s403 lab=0}
N 22400 920 22430 920 {lab=0}
C {devices/gnd.sym} 22430 920 0 0 {name=s404 lab=0}
N 26080 950 26080 970 {lab=0}
C {devices/gnd.sym} 26080 970 0 0 {name=s405 lab=0}
N 26080 920 26110 920 {lab=0}
C {devices/gnd.sym} 26110 920 0 0 {name=s406 lab=0}
N 26080 770 26110 770 {lab=0}
C {devices/gnd.sym} 26110 770 0 0 {name=s407 lab=0}
N 26280 620 26310 620 {lab=0}
C {devices/gnd.sym} 26310 620 0 0 {name=s408 lab=0}
N 26280 770 26310 770 {lab=0}
C {devices/gnd.sym} 26310 770 0 0 {name=s409 lab=0}
N 26280 950 26280 970 {lab=0}
C {devices/gnd.sym} 26280 970 0 0 {name=s410 lab=0}
N 26280 920 26310 920 {lab=0}
C {devices/gnd.sym} 26310 920 0 0 {name=s411 lab=0}
N 26840 950 26840 970 {lab=0}
C {devices/gnd.sym} 26840 970 0 0 {name=s412 lab=0}
N 26840 920 26870 920 {lab=0}
C {devices/gnd.sym} 26870 920 0 0 {name=s413 lab=0}
N 26840 770 26870 770 {lab=0}
C {devices/gnd.sym} 26870 770 0 0 {name=s414 lab=0}
N 27040 770 27070 770 {lab=0}
C {devices/gnd.sym} 27070 770 0 0 {name=s415 lab=0}
N 27040 950 27040 970 {lab=0}
C {devices/gnd.sym} 27040 970 0 0 {name=s416 lab=0}
N 27040 920 27070 920 {lab=0}
C {devices/gnd.sym} 27070 920 0 0 {name=s417 lab=0}
N 24080 950 24080 970 {lab=0}
C {devices/gnd.sym} 24080 970 0 0 {name=s418 lab=0}
N 24080 920 24110 920 {lab=0}
C {devices/gnd.sym} 24110 920 0 0 {name=s419 lab=0}
N 24080 770 24110 770 {lab=0}
C {devices/gnd.sym} 24110 770 0 0 {name=s420 lab=0}
N 24640 950 24640 970 {lab=0}
C {devices/gnd.sym} 24640 970 0 0 {name=s421 lab=0}
N 24640 920 24670 920 {lab=0}
C {devices/gnd.sym} 24670 920 0 0 {name=s422 lab=0}
N 22040 30 22040 10 {lab=VDD}
C {devices/vdd.sym} 22040 10 0 0 {name=s423 lab=VDD}
N 22040 60 22070 60 {lab=VDD}
C {devices/vdd.sym} 22070 60 0 0 {name=s424 lab=VDD}
N 22400 30 22400 10 {lab=VDD}
C {devices/vdd.sym} 22400 10 0 0 {name=s425 lab=VDD}
N 22400 60 22430 60 {lab=VDD}
C {devices/vdd.sym} 22430 60 0 0 {name=s426 lab=VDD}
N 26080 30 26080 10 {lab=VDD}
C {devices/vdd.sym} 26080 10 0 0 {name=s427 lab=VDD}
N 26080 60 26110 60 {lab=VDD}
C {devices/vdd.sym} 26110 60 0 0 {name=s428 lab=VDD}
N 26080 210 26110 210 {lab=VDD}
C {devices/vdd.sym} 26110 210 0 0 {name=s429 lab=VDD}
N 26480 210 26510 210 {lab=VDD}
C {devices/vdd.sym} 26510 210 0 0 {name=s430 lab=VDD}
N 26280 30 26280 10 {lab=VDD}
C {devices/vdd.sym} 26280 10 0 0 {name=s431 lab=VDD}
N 26280 60 26310 60 {lab=VDD}
C {devices/vdd.sym} 26310 60 0 0 {name=s432 lab=VDD}
N 26480 30 26480 10 {lab=VDD}
C {devices/vdd.sym} 26480 10 0 0 {name=s433 lab=VDD}
N 26480 60 26510 60 {lab=VDD}
C {devices/vdd.sym} 26510 60 0 0 {name=s434 lab=VDD}
N 26840 30 26840 10 {lab=VDD}
C {devices/vdd.sym} 26840 10 0 0 {name=s435 lab=VDD}
N 26840 60 26870 60 {lab=VDD}
C {devices/vdd.sym} 26870 60 0 0 {name=s436 lab=VDD}
N 26840 210 26870 210 {lab=VDD}
C {devices/vdd.sym} 26870 210 0 0 {name=s437 lab=VDD}
N 27040 210 27070 210 {lab=VDD}
C {devices/vdd.sym} 27070 210 0 0 {name=s438 lab=VDD}
N 27040 30 27040 10 {lab=VDD}
C {devices/vdd.sym} 27040 10 0 0 {name=s439 lab=VDD}
N 27040 60 27070 60 {lab=VDD}
C {devices/vdd.sym} 27070 60 0 0 {name=s440 lab=VDD}
N 24080 30 24080 10 {lab=VDD}
C {devices/vdd.sym} 24080 10 0 0 {name=s441 lab=VDD}
N 24080 60 24110 60 {lab=VDD}
C {devices/vdd.sym} 24110 60 0 0 {name=s442 lab=VDD}
N 24280 30 24280 10 {lab=VDD}
C {devices/vdd.sym} 24280 10 0 0 {name=s443 lab=VDD}
N 24280 60 24310 60 {lab=VDD}
C {devices/vdd.sym} 24310 60 0 0 {name=s444 lab=VDD}
N 24640 30 24640 10 {lab=VDD}
C {devices/vdd.sym} 24640 10 0 0 {name=s445 lab=VDD}
N 24640 60 24670 60 {lab=VDD}
C {devices/vdd.sym} 24670 60 0 0 {name=s446 lab=VDD}
N 25000 950 25000 970 {lab=0}
C {devices/gnd.sym} 25000 970 0 0 {name=s447 lab=0}
N 25000 920 25030 920 {lab=0}
C {devices/gnd.sym} 25030 920 0 0 {name=s448 lab=0}
N 25000 30 25000 10 {lab=VDD}
C {devices/vdd.sym} 25000 10 0 0 {name=s449 lab=VDD}
N 25000 60 25030 60 {lab=VDD}
C {devices/vdd.sym} 25030 60 0 0 {name=s450 lab=VDD}
N 25360 950 25360 970 {lab=0}
C {devices/gnd.sym} 25360 970 0 0 {name=s451 lab=0}
N 25360 920 25390 920 {lab=0}
C {devices/gnd.sym} 25390 920 0 0 {name=s452 lab=0}
N 25720 950 25720 970 {lab=0}
C {devices/gnd.sym} 25720 970 0 0 {name=s453 lab=0}
N 25720 920 25750 920 {lab=0}
C {devices/gnd.sym} 25750 920 0 0 {name=s454 lab=0}
N 29400 950 29400 970 {lab=0}
C {devices/gnd.sym} 29400 970 0 0 {name=s455 lab=0}
N 29400 920 29430 920 {lab=0}
C {devices/gnd.sym} 29430 920 0 0 {name=s456 lab=0}
N 29400 770 29430 770 {lab=0}
C {devices/gnd.sym} 29430 770 0 0 {name=s457 lab=0}
N 29600 620 29630 620 {lab=0}
C {devices/gnd.sym} 29630 620 0 0 {name=s458 lab=0}
N 29600 770 29630 770 {lab=0}
C {devices/gnd.sym} 29630 770 0 0 {name=s459 lab=0}
N 29600 950 29600 970 {lab=0}
C {devices/gnd.sym} 29600 970 0 0 {name=s460 lab=0}
N 29600 920 29630 920 {lab=0}
C {devices/gnd.sym} 29630 920 0 0 {name=s461 lab=0}
N 30160 950 30160 970 {lab=0}
C {devices/gnd.sym} 30160 970 0 0 {name=s462 lab=0}
N 30160 920 30190 920 {lab=0}
C {devices/gnd.sym} 30190 920 0 0 {name=s463 lab=0}
N 30160 770 30190 770 {lab=0}
C {devices/gnd.sym} 30190 770 0 0 {name=s464 lab=0}
N 30360 770 30390 770 {lab=0}
C {devices/gnd.sym} 30390 770 0 0 {name=s465 lab=0}
N 30360 950 30360 970 {lab=0}
C {devices/gnd.sym} 30360 970 0 0 {name=s466 lab=0}
N 30360 920 30390 920 {lab=0}
C {devices/gnd.sym} 30390 920 0 0 {name=s467 lab=0}
N 27400 950 27400 970 {lab=0}
C {devices/gnd.sym} 27400 970 0 0 {name=s468 lab=0}
N 27400 920 27430 920 {lab=0}
C {devices/gnd.sym} 27430 920 0 0 {name=s469 lab=0}
N 27400 770 27430 770 {lab=0}
C {devices/gnd.sym} 27430 770 0 0 {name=s470 lab=0}
N 27960 950 27960 970 {lab=0}
C {devices/gnd.sym} 27960 970 0 0 {name=s471 lab=0}
N 27960 920 27990 920 {lab=0}
C {devices/gnd.sym} 27990 920 0 0 {name=s472 lab=0}
N 25360 30 25360 10 {lab=VDD}
C {devices/vdd.sym} 25360 10 0 0 {name=s473 lab=VDD}
N 25360 60 25390 60 {lab=VDD}
C {devices/vdd.sym} 25390 60 0 0 {name=s474 lab=VDD}
N 25720 30 25720 10 {lab=VDD}
C {devices/vdd.sym} 25720 10 0 0 {name=s475 lab=VDD}
N 25720 60 25750 60 {lab=VDD}
C {devices/vdd.sym} 25750 60 0 0 {name=s476 lab=VDD}
N 29400 30 29400 10 {lab=VDD}
C {devices/vdd.sym} 29400 10 0 0 {name=s477 lab=VDD}
N 29400 60 29430 60 {lab=VDD}
C {devices/vdd.sym} 29430 60 0 0 {name=s478 lab=VDD}
N 29400 210 29430 210 {lab=VDD}
C {devices/vdd.sym} 29430 210 0 0 {name=s479 lab=VDD}
N 29800 210 29830 210 {lab=VDD}
C {devices/vdd.sym} 29830 210 0 0 {name=s480 lab=VDD}
N 29600 30 29600 10 {lab=VDD}
C {devices/vdd.sym} 29600 10 0 0 {name=s481 lab=VDD}
N 29600 60 29630 60 {lab=VDD}
C {devices/vdd.sym} 29630 60 0 0 {name=s482 lab=VDD}
N 29800 30 29800 10 {lab=VDD}
C {devices/vdd.sym} 29800 10 0 0 {name=s483 lab=VDD}
N 29800 60 29830 60 {lab=VDD}
C {devices/vdd.sym} 29830 60 0 0 {name=s484 lab=VDD}
N 30160 30 30160 10 {lab=VDD}
C {devices/vdd.sym} 30160 10 0 0 {name=s485 lab=VDD}
N 30160 60 30190 60 {lab=VDD}
C {devices/vdd.sym} 30190 60 0 0 {name=s486 lab=VDD}
N 30160 210 30190 210 {lab=VDD}
C {devices/vdd.sym} 30190 210 0 0 {name=s487 lab=VDD}
N 30360 210 30390 210 {lab=VDD}
C {devices/vdd.sym} 30390 210 0 0 {name=s488 lab=VDD}
N 30360 30 30360 10 {lab=VDD}
C {devices/vdd.sym} 30360 10 0 0 {name=s489 lab=VDD}
N 30360 60 30390 60 {lab=VDD}
C {devices/vdd.sym} 30390 60 0 0 {name=s490 lab=VDD}
N 27400 30 27400 10 {lab=VDD}
C {devices/vdd.sym} 27400 10 0 0 {name=s491 lab=VDD}
N 27400 60 27430 60 {lab=VDD}
C {devices/vdd.sym} 27430 60 0 0 {name=s492 lab=VDD}
N 27600 30 27600 10 {lab=VDD}
C {devices/vdd.sym} 27600 10 0 0 {name=s493 lab=VDD}
N 27600 60 27630 60 {lab=VDD}
C {devices/vdd.sym} 27630 60 0 0 {name=s494 lab=VDD}
N 27960 30 27960 10 {lab=VDD}
C {devices/vdd.sym} 27960 10 0 0 {name=s495 lab=VDD}
N 27960 60 27990 60 {lab=VDD}
C {devices/vdd.sym} 27990 60 0 0 {name=s496 lab=VDD}
N 28320 950 28320 970 {lab=0}
C {devices/gnd.sym} 28320 970 0 0 {name=s497 lab=0}
N 28320 920 28350 920 {lab=0}
C {devices/gnd.sym} 28350 920 0 0 {name=s498 lab=0}
N 28320 30 28320 10 {lab=VDD}
C {devices/vdd.sym} 28320 10 0 0 {name=s499 lab=VDD}
N 28320 60 28350 60 {lab=VDD}
C {devices/vdd.sym} 28350 60 0 0 {name=s500 lab=VDD}
N 28680 950 28680 970 {lab=0}
C {devices/gnd.sym} 28680 970 0 0 {name=s501 lab=0}
N 28680 920 28710 920 {lab=0}
C {devices/gnd.sym} 28710 920 0 0 {name=s502 lab=0}
N 29040 950 29040 970 {lab=0}
C {devices/gnd.sym} 29040 970 0 0 {name=s503 lab=0}
N 29040 920 29070 920 {lab=0}
C {devices/gnd.sym} 29070 920 0 0 {name=s504 lab=0}
N 32720 950 32720 970 {lab=0}
C {devices/gnd.sym} 32720 970 0 0 {name=s505 lab=0}
N 32720 920 32750 920 {lab=0}
C {devices/gnd.sym} 32750 920 0 0 {name=s506 lab=0}
N 32720 770 32750 770 {lab=0}
C {devices/gnd.sym} 32750 770 0 0 {name=s507 lab=0}
N 32920 620 32950 620 {lab=0}
C {devices/gnd.sym} 32950 620 0 0 {name=s508 lab=0}
N 32920 770 32950 770 {lab=0}
C {devices/gnd.sym} 32950 770 0 0 {name=s509 lab=0}
N 32920 950 32920 970 {lab=0}
C {devices/gnd.sym} 32920 970 0 0 {name=s510 lab=0}
N 32920 920 32950 920 {lab=0}
C {devices/gnd.sym} 32950 920 0 0 {name=s511 lab=0}
N 33480 950 33480 970 {lab=0}
C {devices/gnd.sym} 33480 970 0 0 {name=s512 lab=0}
N 33480 920 33510 920 {lab=0}
C {devices/gnd.sym} 33510 920 0 0 {name=s513 lab=0}
N 33480 770 33510 770 {lab=0}
C {devices/gnd.sym} 33510 770 0 0 {name=s514 lab=0}
N 33680 770 33710 770 {lab=0}
C {devices/gnd.sym} 33710 770 0 0 {name=s515 lab=0}
N 33680 950 33680 970 {lab=0}
C {devices/gnd.sym} 33680 970 0 0 {name=s516 lab=0}
N 33680 920 33710 920 {lab=0}
C {devices/gnd.sym} 33710 920 0 0 {name=s517 lab=0}
N 30720 950 30720 970 {lab=0}
C {devices/gnd.sym} 30720 970 0 0 {name=s518 lab=0}
N 30720 920 30750 920 {lab=0}
C {devices/gnd.sym} 30750 920 0 0 {name=s519 lab=0}
N 30720 770 30750 770 {lab=0}
C {devices/gnd.sym} 30750 770 0 0 {name=s520 lab=0}
N 31280 950 31280 970 {lab=0}
C {devices/gnd.sym} 31280 970 0 0 {name=s521 lab=0}
N 31280 920 31310 920 {lab=0}
C {devices/gnd.sym} 31310 920 0 0 {name=s522 lab=0}
N 28680 30 28680 10 {lab=VDD}
C {devices/vdd.sym} 28680 10 0 0 {name=s523 lab=VDD}
N 28680 60 28710 60 {lab=VDD}
C {devices/vdd.sym} 28710 60 0 0 {name=s524 lab=VDD}
N 29040 30 29040 10 {lab=VDD}
C {devices/vdd.sym} 29040 10 0 0 {name=s525 lab=VDD}
N 29040 60 29070 60 {lab=VDD}
C {devices/vdd.sym} 29070 60 0 0 {name=s526 lab=VDD}
N 32720 30 32720 10 {lab=VDD}
C {devices/vdd.sym} 32720 10 0 0 {name=s527 lab=VDD}
N 32720 60 32750 60 {lab=VDD}
C {devices/vdd.sym} 32750 60 0 0 {name=s528 lab=VDD}
N 32720 210 32750 210 {lab=VDD}
C {devices/vdd.sym} 32750 210 0 0 {name=s529 lab=VDD}
N 33120 210 33150 210 {lab=VDD}
C {devices/vdd.sym} 33150 210 0 0 {name=s530 lab=VDD}
N 32920 30 32920 10 {lab=VDD}
C {devices/vdd.sym} 32920 10 0 0 {name=s531 lab=VDD}
N 32920 60 32950 60 {lab=VDD}
C {devices/vdd.sym} 32950 60 0 0 {name=s532 lab=VDD}
N 33120 30 33120 10 {lab=VDD}
C {devices/vdd.sym} 33120 10 0 0 {name=s533 lab=VDD}
N 33120 60 33150 60 {lab=VDD}
C {devices/vdd.sym} 33150 60 0 0 {name=s534 lab=VDD}
N 33480 30 33480 10 {lab=VDD}
C {devices/vdd.sym} 33480 10 0 0 {name=s535 lab=VDD}
N 33480 60 33510 60 {lab=VDD}
C {devices/vdd.sym} 33510 60 0 0 {name=s536 lab=VDD}
N 33480 210 33510 210 {lab=VDD}
C {devices/vdd.sym} 33510 210 0 0 {name=s537 lab=VDD}
N 33680 210 33710 210 {lab=VDD}
C {devices/vdd.sym} 33710 210 0 0 {name=s538 lab=VDD}
N 33680 30 33680 10 {lab=VDD}
C {devices/vdd.sym} 33680 10 0 0 {name=s539 lab=VDD}
N 33680 60 33710 60 {lab=VDD}
C {devices/vdd.sym} 33710 60 0 0 {name=s540 lab=VDD}
N 30720 30 30720 10 {lab=VDD}
C {devices/vdd.sym} 30720 10 0 0 {name=s541 lab=VDD}
N 30720 60 30750 60 {lab=VDD}
C {devices/vdd.sym} 30750 60 0 0 {name=s542 lab=VDD}
N 30920 30 30920 10 {lab=VDD}
C {devices/vdd.sym} 30920 10 0 0 {name=s543 lab=VDD}
N 30920 60 30950 60 {lab=VDD}
C {devices/vdd.sym} 30950 60 0 0 {name=s544 lab=VDD}
N 31280 30 31280 10 {lab=VDD}
C {devices/vdd.sym} 31280 10 0 0 {name=s545 lab=VDD}
N 31280 60 31310 60 {lab=VDD}
C {devices/vdd.sym} 31310 60 0 0 {name=s546 lab=VDD}
N 31640 950 31640 970 {lab=0}
C {devices/gnd.sym} 31640 970 0 0 {name=s547 lab=0}
N 31640 920 31670 920 {lab=0}
C {devices/gnd.sym} 31670 920 0 0 {name=s548 lab=0}
N 31640 30 31640 10 {lab=VDD}
C {devices/vdd.sym} 31640 10 0 0 {name=s549 lab=VDD}
N 31640 60 31670 60 {lab=VDD}
C {devices/vdd.sym} 31670 60 0 0 {name=s550 lab=VDD}
N 32000 950 32000 970 {lab=0}
C {devices/gnd.sym} 32000 970 0 0 {name=s551 lab=0}
N 32000 920 32030 920 {lab=0}
C {devices/gnd.sym} 32030 920 0 0 {name=s552 lab=0}
N 32360 950 32360 970 {lab=0}
C {devices/gnd.sym} 32360 970 0 0 {name=s553 lab=0}
N 32360 920 32390 920 {lab=0}
C {devices/gnd.sym} 32390 920 0 0 {name=s554 lab=0}
N 36040 950 36040 970 {lab=0}
C {devices/gnd.sym} 36040 970 0 0 {name=s555 lab=0}
N 36040 920 36070 920 {lab=0}
C {devices/gnd.sym} 36070 920 0 0 {name=s556 lab=0}
N 36040 770 36070 770 {lab=0}
C {devices/gnd.sym} 36070 770 0 0 {name=s557 lab=0}
N 36240 620 36270 620 {lab=0}
C {devices/gnd.sym} 36270 620 0 0 {name=s558 lab=0}
N 36240 770 36270 770 {lab=0}
C {devices/gnd.sym} 36270 770 0 0 {name=s559 lab=0}
N 36240 950 36240 970 {lab=0}
C {devices/gnd.sym} 36240 970 0 0 {name=s560 lab=0}
N 36240 920 36270 920 {lab=0}
C {devices/gnd.sym} 36270 920 0 0 {name=s561 lab=0}
N 36800 950 36800 970 {lab=0}
C {devices/gnd.sym} 36800 970 0 0 {name=s562 lab=0}
N 36800 920 36830 920 {lab=0}
C {devices/gnd.sym} 36830 920 0 0 {name=s563 lab=0}
N 36800 770 36830 770 {lab=0}
C {devices/gnd.sym} 36830 770 0 0 {name=s564 lab=0}
N 37000 770 37030 770 {lab=0}
C {devices/gnd.sym} 37030 770 0 0 {name=s565 lab=0}
N 37000 950 37000 970 {lab=0}
C {devices/gnd.sym} 37000 970 0 0 {name=s566 lab=0}
N 37000 920 37030 920 {lab=0}
C {devices/gnd.sym} 37030 920 0 0 {name=s567 lab=0}
N 34040 950 34040 970 {lab=0}
C {devices/gnd.sym} 34040 970 0 0 {name=s568 lab=0}
N 34040 920 34070 920 {lab=0}
C {devices/gnd.sym} 34070 920 0 0 {name=s569 lab=0}
N 34040 770 34070 770 {lab=0}
C {devices/gnd.sym} 34070 770 0 0 {name=s570 lab=0}
N 34600 950 34600 970 {lab=0}
C {devices/gnd.sym} 34600 970 0 0 {name=s571 lab=0}
N 34600 920 34630 920 {lab=0}
C {devices/gnd.sym} 34630 920 0 0 {name=s572 lab=0}
N 32000 30 32000 10 {lab=VDD}
C {devices/vdd.sym} 32000 10 0 0 {name=s573 lab=VDD}
N 32000 60 32030 60 {lab=VDD}
C {devices/vdd.sym} 32030 60 0 0 {name=s574 lab=VDD}
N 32360 30 32360 10 {lab=VDD}
C {devices/vdd.sym} 32360 10 0 0 {name=s575 lab=VDD}
N 32360 60 32390 60 {lab=VDD}
C {devices/vdd.sym} 32390 60 0 0 {name=s576 lab=VDD}
N 36040 30 36040 10 {lab=VDD}
C {devices/vdd.sym} 36040 10 0 0 {name=s577 lab=VDD}
N 36040 60 36070 60 {lab=VDD}
C {devices/vdd.sym} 36070 60 0 0 {name=s578 lab=VDD}
N 36040 210 36070 210 {lab=VDD}
C {devices/vdd.sym} 36070 210 0 0 {name=s579 lab=VDD}
N 36440 210 36470 210 {lab=VDD}
C {devices/vdd.sym} 36470 210 0 0 {name=s580 lab=VDD}
N 36240 30 36240 10 {lab=VDD}
C {devices/vdd.sym} 36240 10 0 0 {name=s581 lab=VDD}
N 36240 60 36270 60 {lab=VDD}
C {devices/vdd.sym} 36270 60 0 0 {name=s582 lab=VDD}
N 36440 30 36440 10 {lab=VDD}
C {devices/vdd.sym} 36440 10 0 0 {name=s583 lab=VDD}
N 36440 60 36470 60 {lab=VDD}
C {devices/vdd.sym} 36470 60 0 0 {name=s584 lab=VDD}
N 36800 30 36800 10 {lab=VDD}
C {devices/vdd.sym} 36800 10 0 0 {name=s585 lab=VDD}
N 36800 60 36830 60 {lab=VDD}
C {devices/vdd.sym} 36830 60 0 0 {name=s586 lab=VDD}
N 36800 210 36830 210 {lab=VDD}
C {devices/vdd.sym} 36830 210 0 0 {name=s587 lab=VDD}
N 37000 210 37030 210 {lab=VDD}
C {devices/vdd.sym} 37030 210 0 0 {name=s588 lab=VDD}
N 37000 30 37000 10 {lab=VDD}
C {devices/vdd.sym} 37000 10 0 0 {name=s589 lab=VDD}
N 37000 60 37030 60 {lab=VDD}
C {devices/vdd.sym} 37030 60 0 0 {name=s590 lab=VDD}
N 34040 30 34040 10 {lab=VDD}
C {devices/vdd.sym} 34040 10 0 0 {name=s591 lab=VDD}
N 34040 60 34070 60 {lab=VDD}
C {devices/vdd.sym} 34070 60 0 0 {name=s592 lab=VDD}
N 34240 30 34240 10 {lab=VDD}
C {devices/vdd.sym} 34240 10 0 0 {name=s593 lab=VDD}
N 34240 60 34270 60 {lab=VDD}
C {devices/vdd.sym} 34270 60 0 0 {name=s594 lab=VDD}
N 34600 30 34600 10 {lab=VDD}
C {devices/vdd.sym} 34600 10 0 0 {name=s595 lab=VDD}
N 34600 60 34630 60 {lab=VDD}
C {devices/vdd.sym} 34630 60 0 0 {name=s596 lab=VDD}
N 34960 950 34960 970 {lab=0}
C {devices/gnd.sym} 34960 970 0 0 {name=s597 lab=0}
N 34960 920 34990 920 {lab=0}
C {devices/gnd.sym} 34990 920 0 0 {name=s598 lab=0}
N 34960 30 34960 10 {lab=VDD}
C {devices/vdd.sym} 34960 10 0 0 {name=s599 lab=VDD}
N 34960 60 34990 60 {lab=VDD}
C {devices/vdd.sym} 34990 60 0 0 {name=s600 lab=VDD}
N 35320 950 35320 970 {lab=0}
C {devices/gnd.sym} 35320 970 0 0 {name=s601 lab=0}
N 35320 920 35350 920 {lab=0}
C {devices/gnd.sym} 35350 920 0 0 {name=s602 lab=0}
N 35680 950 35680 970 {lab=0}
C {devices/gnd.sym} 35680 970 0 0 {name=s603 lab=0}
N 35680 920 35710 920 {lab=0}
C {devices/gnd.sym} 35710 920 0 0 {name=s604 lab=0}
N 39360 950 39360 970 {lab=0}
C {devices/gnd.sym} 39360 970 0 0 {name=s605 lab=0}
N 39360 920 39390 920 {lab=0}
C {devices/gnd.sym} 39390 920 0 0 {name=s606 lab=0}
N 39360 770 39390 770 {lab=0}
C {devices/gnd.sym} 39390 770 0 0 {name=s607 lab=0}
N 39560 620 39590 620 {lab=0}
C {devices/gnd.sym} 39590 620 0 0 {name=s608 lab=0}
N 39560 770 39590 770 {lab=0}
C {devices/gnd.sym} 39590 770 0 0 {name=s609 lab=0}
N 39560 950 39560 970 {lab=0}
C {devices/gnd.sym} 39560 970 0 0 {name=s610 lab=0}
N 39560 920 39590 920 {lab=0}
C {devices/gnd.sym} 39590 920 0 0 {name=s611 lab=0}
N 40120 950 40120 970 {lab=0}
C {devices/gnd.sym} 40120 970 0 0 {name=s612 lab=0}
N 40120 920 40150 920 {lab=0}
C {devices/gnd.sym} 40150 920 0 0 {name=s613 lab=0}
N 40120 770 40150 770 {lab=0}
C {devices/gnd.sym} 40150 770 0 0 {name=s614 lab=0}
N 40320 770 40350 770 {lab=0}
C {devices/gnd.sym} 40350 770 0 0 {name=s615 lab=0}
N 40320 950 40320 970 {lab=0}
C {devices/gnd.sym} 40320 970 0 0 {name=s616 lab=0}
N 40320 920 40350 920 {lab=0}
C {devices/gnd.sym} 40350 920 0 0 {name=s617 lab=0}
N 37360 950 37360 970 {lab=0}
C {devices/gnd.sym} 37360 970 0 0 {name=s618 lab=0}
N 37360 920 37390 920 {lab=0}
C {devices/gnd.sym} 37390 920 0 0 {name=s619 lab=0}
N 37360 770 37390 770 {lab=0}
C {devices/gnd.sym} 37390 770 0 0 {name=s620 lab=0}
N 37920 950 37920 970 {lab=0}
C {devices/gnd.sym} 37920 970 0 0 {name=s621 lab=0}
N 37920 920 37950 920 {lab=0}
C {devices/gnd.sym} 37950 920 0 0 {name=s622 lab=0}
N 35320 30 35320 10 {lab=VDD}
C {devices/vdd.sym} 35320 10 0 0 {name=s623 lab=VDD}
N 35320 60 35350 60 {lab=VDD}
C {devices/vdd.sym} 35350 60 0 0 {name=s624 lab=VDD}
N 35680 30 35680 10 {lab=VDD}
C {devices/vdd.sym} 35680 10 0 0 {name=s625 lab=VDD}
N 35680 60 35710 60 {lab=VDD}
C {devices/vdd.sym} 35710 60 0 0 {name=s626 lab=VDD}
N 39360 30 39360 10 {lab=VDD}
C {devices/vdd.sym} 39360 10 0 0 {name=s627 lab=VDD}
N 39360 60 39390 60 {lab=VDD}
C {devices/vdd.sym} 39390 60 0 0 {name=s628 lab=VDD}
N 39360 210 39390 210 {lab=VDD}
C {devices/vdd.sym} 39390 210 0 0 {name=s629 lab=VDD}
N 39760 210 39790 210 {lab=VDD}
C {devices/vdd.sym} 39790 210 0 0 {name=s630 lab=VDD}
N 39560 30 39560 10 {lab=VDD}
C {devices/vdd.sym} 39560 10 0 0 {name=s631 lab=VDD}
N 39560 60 39590 60 {lab=VDD}
C {devices/vdd.sym} 39590 60 0 0 {name=s632 lab=VDD}
N 39760 30 39760 10 {lab=VDD}
C {devices/vdd.sym} 39760 10 0 0 {name=s633 lab=VDD}
N 39760 60 39790 60 {lab=VDD}
C {devices/vdd.sym} 39790 60 0 0 {name=s634 lab=VDD}
N 40120 30 40120 10 {lab=VDD}
C {devices/vdd.sym} 40120 10 0 0 {name=s635 lab=VDD}
N 40120 60 40150 60 {lab=VDD}
C {devices/vdd.sym} 40150 60 0 0 {name=s636 lab=VDD}
N 40120 210 40150 210 {lab=VDD}
C {devices/vdd.sym} 40150 210 0 0 {name=s637 lab=VDD}
N 40320 210 40350 210 {lab=VDD}
C {devices/vdd.sym} 40350 210 0 0 {name=s638 lab=VDD}
N 40320 30 40320 10 {lab=VDD}
C {devices/vdd.sym} 40320 10 0 0 {name=s639 lab=VDD}
N 40320 60 40350 60 {lab=VDD}
C {devices/vdd.sym} 40350 60 0 0 {name=s640 lab=VDD}
N 37360 30 37360 10 {lab=VDD}
C {devices/vdd.sym} 37360 10 0 0 {name=s641 lab=VDD}
N 37360 60 37390 60 {lab=VDD}
C {devices/vdd.sym} 37390 60 0 0 {name=s642 lab=VDD}
N 37560 30 37560 10 {lab=VDD}
C {devices/vdd.sym} 37560 10 0 0 {name=s643 lab=VDD}
N 37560 60 37590 60 {lab=VDD}
C {devices/vdd.sym} 37590 60 0 0 {name=s644 lab=VDD}
N 37920 30 37920 10 {lab=VDD}
C {devices/vdd.sym} 37920 10 0 0 {name=s645 lab=VDD}
N 37920 60 37950 60 {lab=VDD}
C {devices/vdd.sym} 37950 60 0 0 {name=s646 lab=VDD}
N 38280 950 38280 970 {lab=0}
C {devices/gnd.sym} 38280 970 0 0 {name=s647 lab=0}
N 38280 920 38310 920 {lab=0}
C {devices/gnd.sym} 38310 920 0 0 {name=s648 lab=0}
N 38280 30 38280 10 {lab=VDD}
C {devices/vdd.sym} 38280 10 0 0 {name=s649 lab=VDD}
N 38280 60 38310 60 {lab=VDD}
C {devices/vdd.sym} 38310 60 0 0 {name=s650 lab=VDD}
N 38640 950 38640 970 {lab=0}
C {devices/gnd.sym} 38640 970 0 0 {name=s651 lab=0}
N 38640 920 38670 920 {lab=0}
C {devices/gnd.sym} 38670 920 0 0 {name=s652 lab=0}
N 39000 950 39000 970 {lab=0}
C {devices/gnd.sym} 39000 970 0 0 {name=s653 lab=0}
N 39000 920 39030 920 {lab=0}
C {devices/gnd.sym} 39030 920 0 0 {name=s654 lab=0}
N 42680 950 42680 970 {lab=0}
C {devices/gnd.sym} 42680 970 0 0 {name=s655 lab=0}
N 42680 920 42710 920 {lab=0}
C {devices/gnd.sym} 42710 920 0 0 {name=s656 lab=0}
N 42680 770 42710 770 {lab=0}
C {devices/gnd.sym} 42710 770 0 0 {name=s657 lab=0}
N 42880 620 42910 620 {lab=0}
C {devices/gnd.sym} 42910 620 0 0 {name=s658 lab=0}
N 42880 770 42910 770 {lab=0}
C {devices/gnd.sym} 42910 770 0 0 {name=s659 lab=0}
N 42880 950 42880 970 {lab=0}
C {devices/gnd.sym} 42880 970 0 0 {name=s660 lab=0}
N 42880 920 42910 920 {lab=0}
C {devices/gnd.sym} 42910 920 0 0 {name=s661 lab=0}
N 43440 950 43440 970 {lab=0}
C {devices/gnd.sym} 43440 970 0 0 {name=s662 lab=0}
N 43440 920 43470 920 {lab=0}
C {devices/gnd.sym} 43470 920 0 0 {name=s663 lab=0}
N 43440 770 43470 770 {lab=0}
C {devices/gnd.sym} 43470 770 0 0 {name=s664 lab=0}
N 43640 770 43670 770 {lab=0}
C {devices/gnd.sym} 43670 770 0 0 {name=s665 lab=0}
N 43640 950 43640 970 {lab=0}
C {devices/gnd.sym} 43640 970 0 0 {name=s666 lab=0}
N 43640 920 43670 920 {lab=0}
C {devices/gnd.sym} 43670 920 0 0 {name=s667 lab=0}
N 40680 950 40680 970 {lab=0}
C {devices/gnd.sym} 40680 970 0 0 {name=s668 lab=0}
N 40680 920 40710 920 {lab=0}
C {devices/gnd.sym} 40710 920 0 0 {name=s669 lab=0}
N 40680 770 40710 770 {lab=0}
C {devices/gnd.sym} 40710 770 0 0 {name=s670 lab=0}
N 41240 950 41240 970 {lab=0}
C {devices/gnd.sym} 41240 970 0 0 {name=s671 lab=0}
N 41240 920 41270 920 {lab=0}
C {devices/gnd.sym} 41270 920 0 0 {name=s672 lab=0}
N 38640 30 38640 10 {lab=VDD}
C {devices/vdd.sym} 38640 10 0 0 {name=s673 lab=VDD}
N 38640 60 38670 60 {lab=VDD}
C {devices/vdd.sym} 38670 60 0 0 {name=s674 lab=VDD}
N 39000 30 39000 10 {lab=VDD}
C {devices/vdd.sym} 39000 10 0 0 {name=s675 lab=VDD}
N 39000 60 39030 60 {lab=VDD}
C {devices/vdd.sym} 39030 60 0 0 {name=s676 lab=VDD}
N 42680 30 42680 10 {lab=VDD}
C {devices/vdd.sym} 42680 10 0 0 {name=s677 lab=VDD}
N 42680 60 42710 60 {lab=VDD}
C {devices/vdd.sym} 42710 60 0 0 {name=s678 lab=VDD}
N 42680 210 42710 210 {lab=VDD}
C {devices/vdd.sym} 42710 210 0 0 {name=s679 lab=VDD}
N 43080 210 43110 210 {lab=VDD}
C {devices/vdd.sym} 43110 210 0 0 {name=s680 lab=VDD}
N 42880 30 42880 10 {lab=VDD}
C {devices/vdd.sym} 42880 10 0 0 {name=s681 lab=VDD}
N 42880 60 42910 60 {lab=VDD}
C {devices/vdd.sym} 42910 60 0 0 {name=s682 lab=VDD}
N 43080 30 43080 10 {lab=VDD}
C {devices/vdd.sym} 43080 10 0 0 {name=s683 lab=VDD}
N 43080 60 43110 60 {lab=VDD}
C {devices/vdd.sym} 43110 60 0 0 {name=s684 lab=VDD}
N 43440 30 43440 10 {lab=VDD}
C {devices/vdd.sym} 43440 10 0 0 {name=s685 lab=VDD}
N 43440 60 43470 60 {lab=VDD}
C {devices/vdd.sym} 43470 60 0 0 {name=s686 lab=VDD}
N 43440 210 43470 210 {lab=VDD}
C {devices/vdd.sym} 43470 210 0 0 {name=s687 lab=VDD}
N 43640 210 43670 210 {lab=VDD}
C {devices/vdd.sym} 43670 210 0 0 {name=s688 lab=VDD}
N 43640 30 43640 10 {lab=VDD}
C {devices/vdd.sym} 43640 10 0 0 {name=s689 lab=VDD}
N 43640 60 43670 60 {lab=VDD}
C {devices/vdd.sym} 43670 60 0 0 {name=s690 lab=VDD}
N 40680 30 40680 10 {lab=VDD}
C {devices/vdd.sym} 40680 10 0 0 {name=s691 lab=VDD}
N 40680 60 40710 60 {lab=VDD}
C {devices/vdd.sym} 40710 60 0 0 {name=s692 lab=VDD}
N 40880 30 40880 10 {lab=VDD}
C {devices/vdd.sym} 40880 10 0 0 {name=s693 lab=VDD}
N 40880 60 40910 60 {lab=VDD}
C {devices/vdd.sym} 40910 60 0 0 {name=s694 lab=VDD}
N 41240 30 41240 10 {lab=VDD}
C {devices/vdd.sym} 41240 10 0 0 {name=s695 lab=VDD}
N 41240 60 41270 60 {lab=VDD}
C {devices/vdd.sym} 41270 60 0 0 {name=s696 lab=VDD}
N 41600 950 41600 970 {lab=0}
C {devices/gnd.sym} 41600 970 0 0 {name=s697 lab=0}
N 41600 920 41630 920 {lab=0}
C {devices/gnd.sym} 41630 920 0 0 {name=s698 lab=0}
N 41600 30 41600 10 {lab=VDD}
C {devices/vdd.sym} 41600 10 0 0 {name=s699 lab=VDD}
N 41600 60 41630 60 {lab=VDD}
C {devices/vdd.sym} 41630 60 0 0 {name=s700 lab=VDD}
N 41960 950 41960 970 {lab=0}
C {devices/gnd.sym} 41960 970 0 0 {name=s701 lab=0}
N 41960 920 41990 920 {lab=0}
C {devices/gnd.sym} 41990 920 0 0 {name=s702 lab=0}
N 42320 950 42320 970 {lab=0}
C {devices/gnd.sym} 42320 970 0 0 {name=s703 lab=0}
N 42320 920 42350 920 {lab=0}
C {devices/gnd.sym} 42350 920 0 0 {name=s704 lab=0}
N 47320 950 47320 970 {lab=0}
C {devices/gnd.sym} 47320 970 0 0 {name=s705 lab=0}
N 47320 920 47350 920 {lab=0}
C {devices/gnd.sym} 47350 920 0 0 {name=s706 lab=0}
N 47320 770 47350 770 {lab=0}
C {devices/gnd.sym} 47350 770 0 0 {name=s707 lab=0}
N 47520 620 47550 620 {lab=0}
C {devices/gnd.sym} 47550 620 0 0 {name=s708 lab=0}
N 47520 770 47550 770 {lab=0}
C {devices/gnd.sym} 47550 770 0 0 {name=s709 lab=0}
N 47520 950 47520 970 {lab=0}
C {devices/gnd.sym} 47520 970 0 0 {name=s710 lab=0}
N 47520 920 47550 920 {lab=0}
C {devices/gnd.sym} 47550 920 0 0 {name=s711 lab=0}
N 48080 950 48080 970 {lab=0}
C {devices/gnd.sym} 48080 970 0 0 {name=s712 lab=0}
N 48080 920 48110 920 {lab=0}
C {devices/gnd.sym} 48110 920 0 0 {name=s713 lab=0}
N 48080 770 48110 770 {lab=0}
C {devices/gnd.sym} 48110 770 0 0 {name=s714 lab=0}
N 48280 770 48310 770 {lab=0}
C {devices/gnd.sym} 48310 770 0 0 {name=s715 lab=0}
N 48280 950 48280 970 {lab=0}
C {devices/gnd.sym} 48280 970 0 0 {name=s716 lab=0}
N 48280 920 48310 920 {lab=0}
C {devices/gnd.sym} 48310 920 0 0 {name=s717 lab=0}
N 44000 950 44000 970 {lab=0}
C {devices/gnd.sym} 44000 970 0 0 {name=s718 lab=0}
N 44000 920 44030 920 {lab=0}
C {devices/gnd.sym} 44030 920 0 0 {name=s719 lab=0}
N 44000 770 44030 770 {lab=0}
C {devices/gnd.sym} 44030 770 0 0 {name=s720 lab=0}
N 44560 950 44560 970 {lab=0}
C {devices/gnd.sym} 44560 970 0 0 {name=s721 lab=0}
N 44560 920 44590 920 {lab=0}
C {devices/gnd.sym} 44590 920 0 0 {name=s722 lab=0}
N 41960 30 41960 10 {lab=VDD}
C {devices/vdd.sym} 41960 10 0 0 {name=s723 lab=VDD}
N 41960 60 41990 60 {lab=VDD}
C {devices/vdd.sym} 41990 60 0 0 {name=s724 lab=VDD}
N 42320 30 42320 10 {lab=VDD}
C {devices/vdd.sym} 42320 10 0 0 {name=s725 lab=VDD}
N 42320 60 42350 60 {lab=VDD}
C {devices/vdd.sym} 42350 60 0 0 {name=s726 lab=VDD}
N 47320 30 47320 10 {lab=VDD}
C {devices/vdd.sym} 47320 10 0 0 {name=s727 lab=VDD}
N 47320 60 47350 60 {lab=VDD}
C {devices/vdd.sym} 47350 60 0 0 {name=s728 lab=VDD}
N 47320 210 47350 210 {lab=VDD}
C {devices/vdd.sym} 47350 210 0 0 {name=s729 lab=VDD}
N 47720 210 47750 210 {lab=VDD}
C {devices/vdd.sym} 47750 210 0 0 {name=s730 lab=VDD}
N 47520 30 47520 10 {lab=VDD}
C {devices/vdd.sym} 47520 10 0 0 {name=s731 lab=VDD}
N 47520 60 47550 60 {lab=VDD}
C {devices/vdd.sym} 47550 60 0 0 {name=s732 lab=VDD}
N 47720 30 47720 10 {lab=VDD}
C {devices/vdd.sym} 47720 10 0 0 {name=s733 lab=VDD}
N 47720 60 47750 60 {lab=VDD}
C {devices/vdd.sym} 47750 60 0 0 {name=s734 lab=VDD}
N 48080 30 48080 10 {lab=VDD}
C {devices/vdd.sym} 48080 10 0 0 {name=s735 lab=VDD}
N 48080 60 48110 60 {lab=VDD}
C {devices/vdd.sym} 48110 60 0 0 {name=s736 lab=VDD}
N 48080 210 48110 210 {lab=VDD}
C {devices/vdd.sym} 48110 210 0 0 {name=s737 lab=VDD}
N 48280 210 48310 210 {lab=VDD}
C {devices/vdd.sym} 48310 210 0 0 {name=s738 lab=VDD}
N 48280 30 48280 10 {lab=VDD}
C {devices/vdd.sym} 48280 10 0 0 {name=s739 lab=VDD}
N 48280 60 48310 60 {lab=VDD}
C {devices/vdd.sym} 48310 60 0 0 {name=s740 lab=VDD}
N 44000 30 44000 10 {lab=VDD}
C {devices/vdd.sym} 44000 10 0 0 {name=s741 lab=VDD}
N 44000 60 44030 60 {lab=VDD}
C {devices/vdd.sym} 44030 60 0 0 {name=s742 lab=VDD}
N 44200 30 44200 10 {lab=VDD}
C {devices/vdd.sym} 44200 10 0 0 {name=s743 lab=VDD}
N 44200 60 44230 60 {lab=VDD}
C {devices/vdd.sym} 44230 60 0 0 {name=s744 lab=VDD}
N 44560 30 44560 10 {lab=VDD}
C {devices/vdd.sym} 44560 10 0 0 {name=s745 lab=VDD}
N 44560 60 44590 60 {lab=VDD}
C {devices/vdd.sym} 44590 60 0 0 {name=s746 lab=VDD}
N 45640 950 45640 970 {lab=0}
C {devices/gnd.sym} 45640 970 0 0 {name=s747 lab=0}
N 45640 920 45670 920 {lab=0}
C {devices/gnd.sym} 45670 920 0 0 {name=s748 lab=0}
N 45640 30 45640 10 {lab=VDD}
C {devices/vdd.sym} 45640 10 0 0 {name=s749 lab=VDD}
N 45640 60 45670 60 {lab=VDD}
C {devices/vdd.sym} 45670 60 0 0 {name=s750 lab=VDD}
N 160 950 160 970 {lab=0}
C {devices/gnd.sym} 160 970 0 0 {name=s751 lab=0}
N 160 920 190 920 {lab=0}
C {devices/gnd.sym} 190 920 0 0 {name=s752 lab=0}
N 520 950 520 970 {lab=0}
C {devices/gnd.sym} 520 970 0 0 {name=s753 lab=0}
N 520 920 550 920 {lab=0}
C {devices/gnd.sym} 550 920 0 0 {name=s754 lab=0}
N 52720 950 52720 970 {lab=0}
C {devices/gnd.sym} 52720 970 0 0 {name=s755 lab=0}
N 52720 920 52750 920 {lab=0}
C {devices/gnd.sym} 52750 920 0 0 {name=s756 lab=0}
N 52720 770 52750 770 {lab=0}
C {devices/gnd.sym} 52750 770 0 0 {name=s757 lab=0}
N 52920 620 52950 620 {lab=0}
C {devices/gnd.sym} 52950 620 0 0 {name=s758 lab=0}
N 52920 770 52950 770 {lab=0}
C {devices/gnd.sym} 52950 770 0 0 {name=s759 lab=0}
N 52920 950 52920 970 {lab=0}
C {devices/gnd.sym} 52920 970 0 0 {name=s760 lab=0}
N 52920 920 52950 920 {lab=0}
C {devices/gnd.sym} 52950 920 0 0 {name=s761 lab=0}
N 53480 950 53480 970 {lab=0}
C {devices/gnd.sym} 53480 970 0 0 {name=s762 lab=0}
N 53480 920 53510 920 {lab=0}
C {devices/gnd.sym} 53510 920 0 0 {name=s763 lab=0}
N 53480 770 53510 770 {lab=0}
C {devices/gnd.sym} 53510 770 0 0 {name=s764 lab=0}
N 53680 770 53710 770 {lab=0}
C {devices/gnd.sym} 53710 770 0 0 {name=s765 lab=0}
N 53680 950 53680 970 {lab=0}
C {devices/gnd.sym} 53680 970 0 0 {name=s766 lab=0}
N 53680 920 53710 920 {lab=0}
C {devices/gnd.sym} 53710 920 0 0 {name=s767 lab=0}
N 48640 950 48640 970 {lab=0}
C {devices/gnd.sym} 48640 970 0 0 {name=s768 lab=0}
N 48640 920 48670 920 {lab=0}
C {devices/gnd.sym} 48670 920 0 0 {name=s769 lab=0}
N 48640 770 48670 770 {lab=0}
C {devices/gnd.sym} 48670 770 0 0 {name=s770 lab=0}
N 49200 950 49200 970 {lab=0}
C {devices/gnd.sym} 49200 970 0 0 {name=s771 lab=0}
N 49200 920 49230 920 {lab=0}
C {devices/gnd.sym} 49230 920 0 0 {name=s772 lab=0}
N 160 30 160 10 {lab=VDD}
C {devices/vdd.sym} 160 10 0 0 {name=s773 lab=VDD}
N 160 60 190 60 {lab=VDD}
C {devices/vdd.sym} 190 60 0 0 {name=s774 lab=VDD}
N 520 30 520 10 {lab=VDD}
C {devices/vdd.sym} 520 10 0 0 {name=s775 lab=VDD}
N 520 60 550 60 {lab=VDD}
C {devices/vdd.sym} 550 60 0 0 {name=s776 lab=VDD}
N 52720 30 52720 10 {lab=VDD}
C {devices/vdd.sym} 52720 10 0 0 {name=s777 lab=VDD}
N 52720 60 52750 60 {lab=VDD}
C {devices/vdd.sym} 52750 60 0 0 {name=s778 lab=VDD}
N 52720 210 52750 210 {lab=VDD}
C {devices/vdd.sym} 52750 210 0 0 {name=s779 lab=VDD}
N 53120 210 53150 210 {lab=VDD}
C {devices/vdd.sym} 53150 210 0 0 {name=s780 lab=VDD}
N 52920 30 52920 10 {lab=VDD}
C {devices/vdd.sym} 52920 10 0 0 {name=s781 lab=VDD}
N 52920 60 52950 60 {lab=VDD}
C {devices/vdd.sym} 52950 60 0 0 {name=s782 lab=VDD}
N 53120 30 53120 10 {lab=VDD}
C {devices/vdd.sym} 53120 10 0 0 {name=s783 lab=VDD}
N 53120 60 53150 60 {lab=VDD}
C {devices/vdd.sym} 53150 60 0 0 {name=s784 lab=VDD}
N 53480 30 53480 10 {lab=VDD}
C {devices/vdd.sym} 53480 10 0 0 {name=s785 lab=VDD}
N 53480 60 53510 60 {lab=VDD}
C {devices/vdd.sym} 53510 60 0 0 {name=s786 lab=VDD}
N 53480 210 53510 210 {lab=VDD}
C {devices/vdd.sym} 53510 210 0 0 {name=s787 lab=VDD}
N 53680 210 53710 210 {lab=VDD}
C {devices/vdd.sym} 53710 210 0 0 {name=s788 lab=VDD}
N 53680 30 53680 10 {lab=VDD}
C {devices/vdd.sym} 53680 10 0 0 {name=s789 lab=VDD}
N 53680 60 53710 60 {lab=VDD}
C {devices/vdd.sym} 53710 60 0 0 {name=s790 lab=VDD}
N 48640 30 48640 10 {lab=VDD}
C {devices/vdd.sym} 48640 10 0 0 {name=s791 lab=VDD}
N 48640 60 48670 60 {lab=VDD}
C {devices/vdd.sym} 48670 60 0 0 {name=s792 lab=VDD}
N 48840 30 48840 10 {lab=VDD}
C {devices/vdd.sym} 48840 10 0 0 {name=s793 lab=VDD}
N 48840 60 48870 60 {lab=VDD}
C {devices/vdd.sym} 48870 60 0 0 {name=s794 lab=VDD}
N 49200 30 49200 10 {lab=VDD}
C {devices/vdd.sym} 49200 10 0 0 {name=s795 lab=VDD}
N 49200 60 49230 60 {lab=VDD}
C {devices/vdd.sym} 49230 60 0 0 {name=s796 lab=VDD}
N 49560 950 49560 970 {lab=0}
C {devices/gnd.sym} 49560 970 0 0 {name=s797 lab=0}
N 49560 920 49590 920 {lab=0}
C {devices/gnd.sym} 49590 920 0 0 {name=s798 lab=0}
N 49760 950 49760 970 {lab=0}
C {devices/gnd.sym} 49760 970 0 0 {name=s799 lab=0}
N 49760 920 49790 920 {lab=0}
C {devices/gnd.sym} 49790 920 0 0 {name=s800 lab=0}
N 50120 950 50120 970 {lab=0}
C {devices/gnd.sym} 50120 970 0 0 {name=s801 lab=0}
N 50120 920 50150 920 {lab=0}
C {devices/gnd.sym} 50150 920 0 0 {name=s802 lab=0}
N 50120 770 50150 770 {lab=0}
C {devices/gnd.sym} 50150 770 0 0 {name=s803 lab=0}
N 50320 950 50320 970 {lab=0}
C {devices/gnd.sym} 50320 970 0 0 {name=s804 lab=0}
N 50320 920 50350 920 {lab=0}
C {devices/gnd.sym} 50350 920 0 0 {name=s805 lab=0}
N 49560 210 49590 210 {lab=VDD}
C {devices/vdd.sym} 49590 210 0 0 {name=s806 lab=VDD}
N 49560 30 49560 10 {lab=VDD}
C {devices/vdd.sym} 49560 10 0 0 {name=s807 lab=VDD}
N 49560 60 49590 60 {lab=VDD}
C {devices/vdd.sym} 49590 60 0 0 {name=s808 lab=VDD}
N 50120 30 50120 10 {lab=VDD}
C {devices/vdd.sym} 50120 10 0 0 {name=s809 lab=VDD}
N 50120 60 50150 60 {lab=VDD}
C {devices/vdd.sym} 50150 60 0 0 {name=s810 lab=VDD}
N 50120 210 50150 210 {lab=VDD}
C {devices/vdd.sym} 50150 210 0 0 {name=s811 lab=VDD}
N 50320 210 50350 210 {lab=VDD}
C {devices/vdd.sym} 50350 210 0 0 {name=s812 lab=VDD}
N 46160 920 46150 920 {lab=run}
N 46150 920 46150 880 {lab=run}
N 46150 880 43950 880 {lab=run}
N 46150 880 46240 880 {lab=run}
N 46240 880 47360 880 {lab=run}
N 46240 880 46240 60 {lab=run}
N 46240 60 46360 60 {lab=run}
N 47360 880 47360 920 {lab=run}
N 47360 920 47470 920 {lab=run}
N 47470 920 47480 920 {lab=run}
N 47470 920 47470 880 {lab=run}
N 43950 880 43030 880 {lab=run}
N 43950 880 43950 60 {lab=run}
N 43950 880 43950 920 {lab=run}
N 43950 920 43960 920 {lab=run}
N 47470 880 47560 880 {lab=run}
N 47560 880 47560 60 {lab=run}
N 47560 880 48320 880 {lab=run}
N 47560 60 47680 60 {lab=run}
N 48320 880 48320 920 {lab=run}
N 48320 920 48590 920 {lab=run}
N 48590 920 48600 920 {lab=run}
N 48590 920 48590 880 {lab=run}
N 43950 60 43960 60 {lab=run}
N 48590 880 48590 60 {lab=run}
N 48590 880 51440 880 {lab=run}
N 48590 60 48600 60 {lab=run}
N 43030 880 42830 880 {lab=run}
N 43030 880 43030 60 {lab=run}
N 42830 880 42830 920 {lab=run}
N 42830 880 40630 880 {lab=run}
N 42830 920 42840 920 {lab=run}
N 43030 60 43040 60 {lab=run}
N 51440 880 51440 920 {lab=run}
N 51440 920 51550 920 {lab=run}
N 51550 920 51560 920 {lab=run}
N 51550 920 51550 880 {lab=run}
N 40630 880 40630 920 {lab=run}
N 40630 880 39710 880 {lab=run}
N 40630 880 40630 60 {lab=run}
N 40630 920 40640 920 {lab=run}
N 40630 60 40640 60 {lab=run}
N 51550 880 51640 880 {lab=run}
N 51640 880 52760 880 {lab=run}
N 51640 880 51640 60 {lab=run}
N 51640 60 51760 60 {lab=run}
N 39710 880 39710 60 {lab=run}
N 39710 880 39510 880 {lab=run}
N 39510 880 39510 920 {lab=run}
N 39510 880 37310 880 {lab=run}
N 39510 920 39520 920 {lab=run}
N 52760 880 52760 920 {lab=run}
N 52760 920 52870 920 {lab=run}
N 52870 920 52880 920 {lab=run}
N 52870 920 52870 880 {lab=run}
N 39710 60 39720 60 {lab=run}
N 52870 880 52960 880 {lab=run}
N 52960 880 52960 60 {lab=run}
N 52960 60 53080 60 {lab=run}
N 37310 880 37310 60 {lab=run}
N 37310 880 36390 880 {lab=run}
N 37310 880 37310 920 {lab=run}
N 37310 920 37320 920 {lab=run}
N 37310 60 37320 60 {lab=run}
N 36390 880 36190 880 {lab=run}
N 36390 880 36390 60 {lab=run}
N 36190 880 33990 880 {lab=run}
N 36190 880 36190 920 {lab=run}
N 36190 920 36200 920 {lab=run}
N 36390 60 36400 60 {lab=run}
N 33990 880 33070 880 {lab=run}
N 33990 880 33990 60 {lab=run}
N 33990 880 33990 920 {lab=run}
N 33990 920 34000 920 {lab=run}
N 33990 60 34000 60 {lab=run}
N 33070 880 32870 880 {lab=run}
N 33070 880 33070 60 {lab=run}
N 32870 880 32870 920 {lab=run}
N 32870 880 30670 880 {lab=run}
N 32870 920 32880 920 {lab=run}
N 33070 60 33080 60 {lab=run}
N 30670 880 30670 920 {lab=run}
N 30670 880 29750 880 {lab=run}
N 30670 880 30670 60 {lab=run}
N 30670 920 30680 920 {lab=run}
N 30670 60 30680 60 {lab=run}
N 29750 880 29550 880 {lab=run}
N 29750 880 29750 60 {lab=run}
N 29550 880 29550 920 {lab=run}
N 29550 880 27350 880 {lab=run}
N 29550 920 29560 920 {lab=run}
N 29750 60 29760 60 {lab=run}
N 27350 880 27350 920 {lab=run}
N 27350 880 26430 880 {lab=run}
N 27350 880 27350 60 {lab=run}
N 27350 920 27360 920 {lab=run}
N 27350 60 27360 60 {lab=run}
N 26430 880 26230 880 {lab=run}
N 26430 880 26430 60 {lab=run}
N 26230 880 24030 880 {lab=run}
N 26230 880 26230 920 {lab=run}
N 26230 920 26240 920 {lab=run}
N 26430 60 26440 60 {lab=run}
N 24030 880 23110 880 {lab=run}
N 24030 880 24030 60 {lab=run}
N 24030 880 24030 920 {lab=run}
N 24030 920 24040 920 {lab=run}
N 24030 60 24040 60 {lab=run}
N 23110 880 22910 880 {lab=run}
N 23110 880 23110 60 {lab=run}
N 22910 880 20710 880 {lab=run}
N 22910 880 22910 920 {lab=run}
N 22910 920 22920 920 {lab=run}
N 23110 60 23120 60 {lab=run}
N 20710 880 20710 60 {lab=run}
N 20710 880 20710 920 {lab=run}
N 20710 880 18710 880 {lab=run}
N 20710 920 20720 920 {lab=run}
N 20710 60 20720 60 {lab=run}
N 18710 880 17790 880 {lab=run}
N 18710 880 18710 60 {lab=run}
N 18710 880 18710 920 {lab=run}
N 18710 920 18720 920 {lab=run}
N 18710 60 18720 60 {lab=run}
N 17790 880 17590 880 {lab=run}
N 17790 880 17790 60 {lab=run}
N 17590 880 16110 880 {lab=run}
N 17590 880 17590 920 {lab=run}
N 17590 920 17600 920 {lab=run}
N 17790 60 17800 60 {lab=run}
N 16110 880 16110 920 {lab=run}
N 16110 880 15190 880 {lab=run}
N 16110 880 16110 60 {lab=run}
N 16110 920 16120 920 {lab=run}
N 16110 60 16120 60 {lab=run}
N 15190 880 14990 880 {lab=run}
N 15190 880 15190 60 {lab=run}
N 14990 880 12790 880 {lab=run}
N 14990 880 14990 920 {lab=run}
N 14990 920 15000 920 {lab=run}
N 15190 60 15200 60 {lab=run}
N 12790 880 11870 880 {lab=run}
N 12790 880 12790 60 {lab=run}
N 12790 880 12790 920 {lab=run}
N 12790 920 12800 920 {lab=run}
N 12790 60 12800 60 {lab=run}
N 11870 880 11670 880 {lab=run}
N 11870 880 11870 60 {lab=run}
N 11670 880 9470 880 {lab=run}
N 11670 880 11670 920 {lab=run}
N 11670 920 11680 920 {lab=run}
N 11870 60 11880 60 {lab=run}
N 9470 880 9470 60 {lab=run}
N 9470 880 9470 920 {lab=run}
N 9470 880 8550 880 {lab=run}
N 9470 920 9480 920 {lab=run}
N 9470 60 9480 60 {lab=run}
N 8550 880 8350 880 {lab=run}
N 8550 880 8550 60 {lab=run}
N 8350 880 8350 920 {lab=run}
N 8350 880 6150 880 {lab=run}
N 8350 920 8360 920 {lab=run}
N 8550 60 8560 60 {lab=run}
N 6150 880 6150 60 {lab=run}
N 6150 880 5230 880 {lab=run}
N 6150 880 6150 920 {lab=run}
N 6150 920 6160 920 {lab=run}
N 6150 60 6160 60 {lab=run}
N 5230 880 5230 60 {lab=run}
N 5230 880 5030 880 {lab=run}
N 5030 880 2830 880 {lab=run}
N 5030 880 5030 920 {lab=run}
N 5030 920 5040 920 {lab=run}
N 5230 60 5240 60 {lab=run}
N 2830 880 830 880 {lab=run}
N 2830 880 2830 60 {lab=run}
N 2830 880 2830 920 {lab=run}
N 2830 920 2840 920 {lab=run}
N 2830 60 2840 60 {lab=run}
N 830 880 830 920 {lab=run}
N 830 880 830 550 {lab=run}
N 830 920 840 920 {lab=run}
N 830 550 -60 550 {lab=run}
N 830 550 830 60 {lab=run}
N 830 60 840 60 {lab=run}
N 50640 920 50630 920 {lab=k_0}
N 50630 920 50630 860 {lab=k_0}
N 50630 860 50630 250 {lab=k_0}
N 50630 860 50070 860 {lab=k_0}
N 50070 860 49710 860 {lab=k_0}
N 50070 860 50070 770 {lab=k_0}
N 50070 770 50080 770 {lab=k_0}
N 50070 770 50070 210 {lab=k_0}
N 50630 250 54060 250 {lab=k_0}
N 50630 250 50630 60 {lab=k_0}
N 50630 60 50640 60 {lab=k_0}
N 49710 860 49710 920 {lab=k_0}
N 49710 860 49510 860 {lab=k_0}
N 49710 920 49720 920 {lab=k_0}
N 50070 210 50080 210 {lab=k_0}
N 49510 860 49200 860 {lab=k_0}
N 49510 860 49510 90 {lab=k_0}
N 49200 860 49200 890 {lab=k_0}
N 49510 90 49200 90 {lab=k_0}
N 49510 90 49510 60 {lab=k_0}
N 49510 60 49520 60 {lab=k_0}
N 160 890 200 890 {lab=k0_ff.ncki}
N 160 890 160 90 {lab=k0_ff.ncki}
N 200 890 200 920 {lab=k0_ff.ncki}
N 200 920 470 920 {lab=k0_ff.ncki}
N 470 920 470 980 {lab=k0_ff.ncki}
N 470 920 480 920 {lab=k0_ff.ncki}
N 160 90 200 90 {lab=k0_ff.ncki}
N 200 90 200 60 {lab=k0_ff.ncki}
N 200 60 480 60 {lab=k0_ff.ncki}
N 470 980 51660 980 {lab=k0_ff.ncki}
N 51660 980 51660 620 {lab=k0_ff.ncki}
N 51660 620 52670 620 {lab=k0_ff.ncki}
N 52670 620 52870 620 {lab=k0_ff.ncki}
N 52670 620 52670 210 {lab=k0_ff.ncki}
N 52870 620 52870 660 {lab=k0_ff.ncki}
N 52870 620 52880 620 {lab=k0_ff.ncki}
N 52670 210 52680 210 {lab=k0_ff.ncki}
N 52870 660 52980 660 {lab=k0_ff.ncki}
N 52980 660 52980 770 {lab=k0_ff.ncki}
N 52980 770 53430 770 {lab=k0_ff.ncki}
N 53430 770 53440 770 {lab=k0_ff.ncki}
N 53430 770 53430 730 {lab=k0_ff.ncki}
N 53430 730 53520 730 {lab=k0_ff.ncki}
N 53520 730 53520 210 {lab=k0_ff.ncki}
N 53520 210 53640 210 {lab=k0_ff.ncki}
N 41960 890 41960 660 {lab=k9_ff.ncki}
N 41960 890 42000 890 {lab=k9_ff.ncki}
N 42000 890 42000 920 {lab=k9_ff.ncki}
N 42000 920 42280 920 {lab=k9_ff.ncki}
N 41960 660 46260 660 {lab=k9_ff.ncki}
N 41960 660 41960 90 {lab=k9_ff.ncki}
N 41960 90 42000 90 {lab=k9_ff.ncki}
N 42000 90 42000 60 {lab=k9_ff.ncki}
N 42000 60 42280 60 {lab=k9_ff.ncki}
N 46260 660 46260 620 {lab=k9_ff.ncki}
N 46260 620 47270 620 {lab=k9_ff.ncki}
N 47270 620 47470 620 {lab=k9_ff.ncki}
N 47270 620 47270 210 {lab=k9_ff.ncki}
N 47470 620 47470 660 {lab=k9_ff.ncki}
N 47470 620 47480 620 {lab=k9_ff.ncki}
N 47270 210 47280 210 {lab=k9_ff.ncki}
N 47470 660 47580 660 {lab=k9_ff.ncki}
N 47580 660 47580 770 {lab=k9_ff.ncki}
N 47580 770 48030 770 {lab=k9_ff.ncki}
N 48030 770 48040 770 {lab=k9_ff.ncki}
N 48030 770 48030 730 {lab=k9_ff.ncki}
N 48030 730 48120 730 {lab=k9_ff.ncki}
N 48120 730 48120 210 {lab=k9_ff.ncki}
N 48120 210 48240 210 {lab=k9_ff.ncki}
N 4160 890 4200 890 {lab=k12_ff.ncki}
N 4160 890 4160 660 {lab=k12_ff.ncki}
N 4200 890 4200 920 {lab=k12_ff.ncki}
N 4200 920 4480 920 {lab=k12_ff.ncki}
N 4160 660 5120 660 {lab=k12_ff.ncki}
N 4160 660 4160 90 {lab=k12_ff.ncki}
N 4160 90 4200 90 {lab=k12_ff.ncki}
N 4200 90 4200 60 {lab=k12_ff.ncki}
N 4200 60 4480 60 {lab=k12_ff.ncki}
N 5120 660 5120 620 {lab=k12_ff.ncki}
N 5120 620 8150 620 {lab=k12_ff.ncki}
N 8150 620 8350 620 {lab=k12_ff.ncki}
N 8150 620 8150 210 {lab=k12_ff.ncki}
N 8350 620 8350 660 {lab=k12_ff.ncki}
N 8350 620 8360 620 {lab=k12_ff.ncki}
N 8150 210 8160 210 {lab=k12_ff.ncki}
N 8350 660 8440 660 {lab=k12_ff.ncki}
N 8440 660 8440 770 {lab=k12_ff.ncki}
N 8440 770 8910 770 {lab=k12_ff.ncki}
N 8910 770 8920 770 {lab=k12_ff.ncki}
N 8910 770 8910 730 {lab=k12_ff.ncki}
N 8910 730 9000 730 {lab=k12_ff.ncki}
N 9000 730 9000 210 {lab=k12_ff.ncki}
N 9000 210 9120 210 {lab=k12_ff.ncki}
N 7480 890 7480 90 {lab=k13_ff.ncki}
N 7480 890 7520 890 {lab=k13_ff.ncki}
N 7520 890 7520 920 {lab=k13_ff.ncki}
N 7520 920 7790 920 {lab=k13_ff.ncki}
N 7790 920 7790 860 {lab=k13_ff.ncki}
N 7790 920 7800 920 {lab=k13_ff.ncki}
N 7480 90 7520 90 {lab=k13_ff.ncki}
N 7520 90 7520 60 {lab=k13_ff.ncki}
N 7520 60 7800 60 {lab=k13_ff.ncki}
N 7790 860 9020 860 {lab=k13_ff.ncki}
N 9020 860 9020 620 {lab=k13_ff.ncki}
N 9020 620 11470 620 {lab=k13_ff.ncki}
N 11470 620 11470 210 {lab=k13_ff.ncki}
N 11470 620 11670 620 {lab=k13_ff.ncki}
N 11670 620 11680 620 {lab=k13_ff.ncki}
N 11670 620 11670 660 {lab=k13_ff.ncki}
N 11470 210 11480 210 {lab=k13_ff.ncki}
N 11670 660 11760 660 {lab=k13_ff.ncki}
N 11760 660 11760 770 {lab=k13_ff.ncki}
N 11760 770 12230 770 {lab=k13_ff.ncki}
N 12230 770 12240 770 {lab=k13_ff.ncki}
N 12230 770 12230 730 {lab=k13_ff.ncki}
N 12230 730 12320 730 {lab=k13_ff.ncki}
N 12320 730 12320 210 {lab=k13_ff.ncki}
N 12320 210 12440 210 {lab=k13_ff.ncki}
N 10800 890 10800 90 {lab=k14_ff.ncki}
N 10800 890 10840 890 {lab=k14_ff.ncki}
N 10840 890 10840 920 {lab=k14_ff.ncki}
N 10840 920 11110 920 {lab=k14_ff.ncki}
N 11110 920 11110 860 {lab=k14_ff.ncki}
N 11110 920 11120 920 {lab=k14_ff.ncki}
N 10800 90 10840 90 {lab=k14_ff.ncki}
N 10840 90 10840 60 {lab=k14_ff.ncki}
N 10840 60 11120 60 {lab=k14_ff.ncki}
N 11110 860 12340 860 {lab=k14_ff.ncki}
N 12340 860 12340 620 {lab=k14_ff.ncki}
N 12340 620 14790 620 {lab=k14_ff.ncki}
N 14790 620 14790 210 {lab=k14_ff.ncki}
N 14790 620 14990 620 {lab=k14_ff.ncki}
N 14990 620 14990 660 {lab=k14_ff.ncki}
N 14990 620 15000 620 {lab=k14_ff.ncki}
N 14790 210 14800 210 {lab=k14_ff.ncki}
N 14990 660 15080 660 {lab=k14_ff.ncki}
N 15080 660 15080 770 {lab=k14_ff.ncki}
N 15080 770 15550 770 {lab=k14_ff.ncki}
N 15550 770 15550 730 {lab=k14_ff.ncki}
N 15550 770 15560 770 {lab=k14_ff.ncki}
N 15550 730 15640 730 {lab=k14_ff.ncki}
N 15640 730 15640 210 {lab=k14_ff.ncki}
N 15640 210 15760 210 {lab=k14_ff.ncki}
N 22040 890 22040 660 {lab=k3_ff.ncki}
N 22040 890 22080 890 {lab=k3_ff.ncki}
N 22080 890 22080 920 {lab=k3_ff.ncki}
N 22080 920 22360 920 {lab=k3_ff.ncki}
N 22040 660 22040 90 {lab=k3_ff.ncki}
N 22040 660 23000 660 {lab=k3_ff.ncki}
N 22040 90 22080 90 {lab=k3_ff.ncki}
N 22080 90 22080 60 {lab=k3_ff.ncki}
N 22080 60 22360 60 {lab=k3_ff.ncki}
N 23000 660 23000 620 {lab=k3_ff.ncki}
N 23000 620 26030 620 {lab=k3_ff.ncki}
N 26030 620 26230 620 {lab=k3_ff.ncki}
N 26030 620 26030 210 {lab=k3_ff.ncki}
N 26230 620 26230 660 {lab=k3_ff.ncki}
N 26230 620 26240 620 {lab=k3_ff.ncki}
N 26030 210 26040 210 {lab=k3_ff.ncki}
N 26230 660 26320 660 {lab=k3_ff.ncki}
N 26320 660 26320 770 {lab=k3_ff.ncki}
N 26320 770 26790 770 {lab=k3_ff.ncki}
N 26790 770 26790 730 {lab=k3_ff.ncki}
N 26790 770 26800 770 {lab=k3_ff.ncki}
N 26790 730 26880 730 {lab=k3_ff.ncki}
N 26880 730 26880 210 {lab=k3_ff.ncki}
N 26880 210 27000 210 {lab=k3_ff.ncki}
N 25360 890 25400 890 {lab=k4_ff.ncki}
N 25360 890 25360 90 {lab=k4_ff.ncki}
N 25400 890 25400 920 {lab=k4_ff.ncki}
N 25400 920 25670 920 {lab=k4_ff.ncki}
N 25670 920 25680 920 {lab=k4_ff.ncki}
N 25670 920 25670 860 {lab=k4_ff.ncki}
N 25360 90 25400 90 {lab=k4_ff.ncki}
N 25400 90 25400 60 {lab=k4_ff.ncki}
N 25400 60 25680 60 {lab=k4_ff.ncki}
N 25670 860 26900 860 {lab=k4_ff.ncki}
N 26900 860 26900 620 {lab=k4_ff.ncki}
N 26900 620 29350 620 {lab=k4_ff.ncki}
N 29350 620 29550 620 {lab=k4_ff.ncki}
N 29350 620 29350 210 {lab=k4_ff.ncki}
N 29550 620 29550 660 {lab=k4_ff.ncki}
N 29550 620 29560 620 {lab=k4_ff.ncki}
N 29350 210 29360 210 {lab=k4_ff.ncki}
N 29550 660 29640 660 {lab=k4_ff.ncki}
N 29640 660 29640 770 {lab=k4_ff.ncki}
N 29640 770 30110 770 {lab=k4_ff.ncki}
N 30110 770 30120 770 {lab=k4_ff.ncki}
N 30110 770 30110 730 {lab=k4_ff.ncki}
N 30110 730 30200 730 {lab=k4_ff.ncki}
N 30200 730 30200 210 {lab=k4_ff.ncki}
N 30200 210 30320 210 {lab=k4_ff.ncki}
N 28680 890 28720 890 {lab=k5_ff.ncki}
N 28680 890 28680 90 {lab=k5_ff.ncki}
N 28720 890 28720 920 {lab=k5_ff.ncki}
N 28720 920 28990 920 {lab=k5_ff.ncki}
N 28990 920 29000 920 {lab=k5_ff.ncki}
N 28990 920 28990 860 {lab=k5_ff.ncki}
N 28680 90 28720 90 {lab=k5_ff.ncki}
N 28720 90 28720 60 {lab=k5_ff.ncki}
N 28720 60 29000 60 {lab=k5_ff.ncki}
N 28990 860 30220 860 {lab=k5_ff.ncki}
N 30220 860 30220 620 {lab=k5_ff.ncki}
N 30220 620 32670 620 {lab=k5_ff.ncki}
N 32670 620 32670 210 {lab=k5_ff.ncki}
N 32670 620 32870 620 {lab=k5_ff.ncki}
N 32870 620 32880 620 {lab=k5_ff.ncki}
N 32870 620 32870 660 {lab=k5_ff.ncki}
N 32670 210 32680 210 {lab=k5_ff.ncki}
N 32870 660 32960 660 {lab=k5_ff.ncki}
N 32960 660 32960 770 {lab=k5_ff.ncki}
N 32960 770 33430 770 {lab=k5_ff.ncki}
N 33430 770 33440 770 {lab=k5_ff.ncki}
N 33430 770 33430 730 {lab=k5_ff.ncki}
N 33430 730 33520 730 {lab=k5_ff.ncki}
N 33520 730 33520 210 {lab=k5_ff.ncki}
N 33520 210 33640 210 {lab=k5_ff.ncki}
N 32000 890 32000 90 {lab=k6_ff.ncki}
N 32000 890 32040 890 {lab=k6_ff.ncki}
N 32040 890 32040 920 {lab=k6_ff.ncki}
N 32040 920 32310 920 {lab=k6_ff.ncki}
N 32310 920 32310 860 {lab=k6_ff.ncki}
N 32310 920 32320 920 {lab=k6_ff.ncki}
N 32000 90 32040 90 {lab=k6_ff.ncki}
N 32040 90 32040 60 {lab=k6_ff.ncki}
N 32040 60 32320 60 {lab=k6_ff.ncki}
N 32310 860 33540 860 {lab=k6_ff.ncki}
N 33540 860 33540 620 {lab=k6_ff.ncki}
N 33540 620 35990 620 {lab=k6_ff.ncki}
N 35990 620 35990 210 {lab=k6_ff.ncki}
N 35990 620 36190 620 {lab=k6_ff.ncki}
N 36190 620 36190 660 {lab=k6_ff.ncki}
N 36190 620 36200 620 {lab=k6_ff.ncki}
N 35990 210 36000 210 {lab=k6_ff.ncki}
N 36190 660 36280 660 {lab=k6_ff.ncki}
N 36280 660 36280 770 {lab=k6_ff.ncki}
N 36280 770 36750 770 {lab=k6_ff.ncki}
N 36750 770 36750 730 {lab=k6_ff.ncki}
N 36750 770 36760 770 {lab=k6_ff.ncki}
N 36750 730 36840 730 {lab=k6_ff.ncki}
N 36840 730 36840 210 {lab=k6_ff.ncki}
N 36840 210 36960 210 {lab=k6_ff.ncki}
N 35320 890 35360 890 {lab=k7_ff.ncki}
N 35320 890 35320 90 {lab=k7_ff.ncki}
N 35360 890 35360 920 {lab=k7_ff.ncki}
N 35360 920 35630 920 {lab=k7_ff.ncki}
N 35630 920 35630 860 {lab=k7_ff.ncki}
N 35630 920 35640 920 {lab=k7_ff.ncki}
N 35320 90 35360 90 {lab=k7_ff.ncki}
N 35360 90 35360 60 {lab=k7_ff.ncki}
N 35360 60 35640 60 {lab=k7_ff.ncki}
N 35630 860 36860 860 {lab=k7_ff.ncki}
N 36860 860 36860 620 {lab=k7_ff.ncki}
N 36860 620 39310 620 {lab=k7_ff.ncki}
N 39310 620 39510 620 {lab=k7_ff.ncki}
N 39310 620 39310 210 {lab=k7_ff.ncki}
N 39510 620 39510 660 {lab=k7_ff.ncki}
N 39510 620 39520 620 {lab=k7_ff.ncki}
N 39310 210 39320 210 {lab=k7_ff.ncki}
N 39510 660 39600 660 {lab=k7_ff.ncki}
N 39600 660 39600 770 {lab=k7_ff.ncki}
N 39600 770 40070 770 {lab=k7_ff.ncki}
N 40070 770 40070 730 {lab=k7_ff.ncki}
N 40070 770 40080 770 {lab=k7_ff.ncki}
N 40070 730 40160 730 {lab=k7_ff.ncki}
N 40160 730 40160 210 {lab=k7_ff.ncki}
N 40160 210 40280 210 {lab=k7_ff.ncki}
N 38640 890 38680 890 {lab=k8_ff.ncki}
N 38640 890 38640 90 {lab=k8_ff.ncki}
N 38680 890 38680 920 {lab=k8_ff.ncki}
N 38680 920 38950 920 {lab=k8_ff.ncki}
N 38950 920 38960 920 {lab=k8_ff.ncki}
N 38950 920 38950 860 {lab=k8_ff.ncki}
N 38640 90 38680 90 {lab=k8_ff.ncki}
N 38680 90 38680 60 {lab=k8_ff.ncki}
N 38680 60 38960 60 {lab=k8_ff.ncki}
N 38950 860 40180 860 {lab=k8_ff.ncki}
N 40180 860 40180 620 {lab=k8_ff.ncki}
N 40180 620 42630 620 {lab=k8_ff.ncki}
N 42630 620 42830 620 {lab=k8_ff.ncki}
N 42630 620 42630 210 {lab=k8_ff.ncki}
N 42830 620 42830 680 {lab=k8_ff.ncki}
N 42830 620 42840 620 {lab=k8_ff.ncki}
N 42630 210 42640 210 {lab=k8_ff.ncki}
N 42830 680 42920 680 {lab=k8_ff.ncki}
N 42920 680 42920 770 {lab=k8_ff.ncki}
N 42920 770 43390 770 {lab=k8_ff.ncki}
N 43390 770 43400 770 {lab=k8_ff.ncki}
N 43390 770 43390 730 {lab=k8_ff.ncki}
N 43390 730 43480 730 {lab=k8_ff.ncki}
N 43480 730 43480 210 {lab=k8_ff.ncki}
N 43480 210 43600 210 {lab=k8_ff.ncki}
N 14120 890 14160 890 {lab=k15_ff.ncki}
N 14120 890 14120 90 {lab=k15_ff.ncki}
N 14160 890 14160 920 {lab=k15_ff.ncki}
N 14160 920 14430 920 {lab=k15_ff.ncki}
N 14430 920 14440 920 {lab=k15_ff.ncki}
N 14430 920 14430 860 {lab=k15_ff.ncki}
N 14120 90 14160 90 {lab=k15_ff.ncki}
N 14160 90 14160 60 {lab=k15_ff.ncki}
N 14160 60 14440 60 {lab=k15_ff.ncki}
N 14430 860 15660 860 {lab=k15_ff.ncki}
N 15660 860 15660 620 {lab=k15_ff.ncki}
N 15660 620 17390 620 {lab=k15_ff.ncki}
N 17390 620 17390 210 {lab=k15_ff.ncki}
N 17390 620 17590 620 {lab=k15_ff.ncki}
N 17590 620 17600 620 {lab=k15_ff.ncki}
N 17590 620 17590 660 {lab=k15_ff.ncki}
N 17390 210 17400 210 {lab=k15_ff.ncki}
N 17590 660 17680 660 {lab=k15_ff.ncki}
N 17680 660 17680 770 {lab=k15_ff.ncki}
N 17680 770 18150 770 {lab=k15_ff.ncki}
N 18150 770 18160 770 {lab=k15_ff.ncki}
N 18150 770 18150 730 {lab=k15_ff.ncki}
N 18150 730 18240 730 {lab=k15_ff.ncki}
N 18240 730 18240 210 {lab=k15_ff.ncki}
N 18240 210 18360 210 {lab=k15_ff.ncki}
N 2160 890 2160 620 {lab=k11_ff.ncki}
N 2160 890 2200 890 {lab=k11_ff.ncki}
N 2200 890 2200 920 {lab=k11_ff.ncki}
N 2200 920 2480 920 {lab=k11_ff.ncki}
N 2160 620 2160 90 {lab=k11_ff.ncki}
N 2160 620 4830 620 {lab=k11_ff.ncki}
N 2160 90 2200 90 {lab=k11_ff.ncki}
N 2200 90 2200 60 {lab=k11_ff.ncki}
N 2200 60 2480 60 {lab=k11_ff.ncki}
N 4830 620 5030 620 {lab=k11_ff.ncki}
N 4830 620 4830 210 {lab=k11_ff.ncki}
N 5030 620 5030 680 {lab=k11_ff.ncki}
N 5030 620 5040 620 {lab=k11_ff.ncki}
N 4830 210 4840 210 {lab=k11_ff.ncki}
N 5030 680 5120 680 {lab=k11_ff.ncki}
N 5120 680 5120 770 {lab=k11_ff.ncki}
N 5120 770 5590 770 {lab=k11_ff.ncki}
N 5590 770 5590 730 {lab=k11_ff.ncki}
N 5590 770 5600 770 {lab=k11_ff.ncki}
N 5590 730 5680 730 {lab=k11_ff.ncki}
N 5680 730 5680 210 {lab=k11_ff.ncki}
N 5680 210 5800 210 {lab=k11_ff.ncki}
N 20040 890 20080 890 {lab=k2_ff.ncki}
N 20040 890 20040 620 {lab=k2_ff.ncki}
N 20080 890 20080 920 {lab=k2_ff.ncki}
N 20080 920 20360 920 {lab=k2_ff.ncki}
N 20040 620 22710 620 {lab=k2_ff.ncki}
N 20040 620 20040 90 {lab=k2_ff.ncki}
N 20040 90 20080 90 {lab=k2_ff.ncki}
N 20080 90 20080 60 {lab=k2_ff.ncki}
N 20080 60 20360 60 {lab=k2_ff.ncki}
N 22710 620 22710 210 {lab=k2_ff.ncki}
N 22710 620 22910 620 {lab=k2_ff.ncki}
N 22910 620 22920 620 {lab=k2_ff.ncki}
N 22910 620 22910 680 {lab=k2_ff.ncki}
N 22710 210 22720 210 {lab=k2_ff.ncki}
N 22910 680 23000 680 {lab=k2_ff.ncki}
N 23000 680 23000 770 {lab=k2_ff.ncki}
N 23000 770 23470 770 {lab=k2_ff.ncki}
N 23470 770 23480 770 {lab=k2_ff.ncki}
N 23470 770 23470 730 {lab=k2_ff.ncki}
N 23470 730 23560 730 {lab=k2_ff.ncki}
N 23560 730 23560 210 {lab=k2_ff.ncki}
N 23560 210 23680 210 {lab=k2_ff.ncki}
N 44920 890 44920 620 {lab=k10_ff.ncki}
N 44920 890 44960 890 {lab=k10_ff.ncki}
N 44960 890 44960 920 {lab=k10_ff.ncki}
N 44960 920 45240 920 {lab=k10_ff.ncki}
N 44920 620 44920 90 {lab=k10_ff.ncki}
N 44920 620 45950 620 {lab=k10_ff.ncki}
N 44920 90 44960 90 {lab=k10_ff.ncki}
N 44960 90 44960 60 {lab=k10_ff.ncki}
N 44960 60 45240 60 {lab=k10_ff.ncki}
N 45950 620 45950 210 {lab=k10_ff.ncki}
N 45950 620 46150 620 {lab=k10_ff.ncki}
N 46150 620 46150 680 {lab=k10_ff.ncki}
N 46150 620 46160 620 {lab=k10_ff.ncki}
N 45950 210 45960 210 {lab=k10_ff.ncki}
N 46150 680 46260 680 {lab=k10_ff.ncki}
N 46260 680 46260 770 {lab=k10_ff.ncki}
N 46260 770 46710 770 {lab=k10_ff.ncki}
N 46710 770 46720 770 {lab=k10_ff.ncki}
N 46710 770 46710 730 {lab=k10_ff.ncki}
N 46710 730 46800 730 {lab=k10_ff.ncki}
N 46800 730 46800 210 {lab=k10_ff.ncki}
N 46800 210 46920 210 {lab=k10_ff.ncki}
N 50680 890 50680 620 {lab=k1_ff.ncki}
N 50680 890 50720 890 {lab=k1_ff.ncki}
N 50720 890 50720 920 {lab=k1_ff.ncki}
N 50720 920 51000 920 {lab=k1_ff.ncki}
N 50680 620 51350 620 {lab=k1_ff.ncki}
N 50680 620 50680 90 {lab=k1_ff.ncki}
N 50680 90 50720 90 {lab=k1_ff.ncki}
N 51350 620 51350 210 {lab=k1_ff.ncki}
N 51350 620 51550 620 {lab=k1_ff.ncki}
N 51550 620 51560 620 {lab=k1_ff.ncki}
N 51550 620 51550 660 {lab=k1_ff.ncki}
N 50720 90 50720 60 {lab=k1_ff.ncki}
N 50720 60 51000 60 {lab=k1_ff.ncki}
N 51350 210 51360 210 {lab=k1_ff.ncki}
N 51550 660 51680 660 {lab=k1_ff.ncki}
N 51680 660 51680 770 {lab=k1_ff.ncki}
N 51680 770 52110 770 {lab=k1_ff.ncki}
N 52110 770 52120 770 {lab=k1_ff.ncki}
N 52110 770 52110 730 {lab=k1_ff.ncki}
N 52110 730 52200 730 {lab=k1_ff.ncki}
N 52200 730 52200 210 {lab=k1_ff.ncki}
N 52200 210 52320 210 {lab=k1_ff.ncki}
N 1440 890 1480 890 {lab=k_10}
N 1440 890 1440 90 {lab=k_10}
N 1480 890 1480 920 {lab=k_10}
N 1480 920 1750 920 {lab=k_10}
N 1750 920 1760 920 {lab=k_10}
N 1750 920 1750 860 {lab=k_10}
N 1750 860 1840 860 {lab=k_10}
N 1840 860 1840 920 {lab=k_10}
N 1840 920 2120 920 {lab=k_10}
N 1440 90 1480 90 {lab=k_10}
N 1480 90 1480 60 {lab=k_10}
N 1480 60 1750 60 {lab=k_10}
N 1750 60 1750 100 {lab=k_10}
N 1750 60 1760 60 {lab=k_10}
N 1750 100 1840 100 {lab=k_10}
N 1840 100 1840 60 {lab=k_10}
N 1840 60 2110 60 {lab=k_10}
N 2110 60 2120 60 {lab=k_10}
N 2110 60 2110 0 {lab=k_10}
N 2110 0 54070 0 {lab=k_10}
N 54070 0 54070 290 {lab=k_10}
N 54070 290 54060 290 {lab=k_10}
N 3440 890 3440 90 {lab=k_11}
N 3440 890 3480 890 {lab=k_11}
N 3480 890 3480 920 {lab=k_11}
N 3480 920 3750 920 {lab=k_11}
N 3750 920 3750 860 {lab=k_11}
N 3750 920 3760 920 {lab=k_11}
N 3750 860 3840 860 {lab=k_11}
N 3840 860 3840 920 {lab=k_11}
N 3840 920 4120 920 {lab=k_11}
N 3440 90 3480 90 {lab=k_11}
N 3480 90 3480 60 {lab=k_11}
N 3480 60 3750 60 {lab=k_11}
N 3750 60 3750 100 {lab=k_11}
N 3750 60 3760 60 {lab=k_11}
N 3750 100 3840 100 {lab=k_11}
N 3840 100 3840 60 {lab=k_11}
N 3840 60 4110 60 {lab=k_11}
N 4110 60 4120 60 {lab=k_11}
N 4110 60 4110 -20 {lab=k_11}
N 4110 -20 54090 -20 {lab=k_11}
N 54090 -20 54090 330 {lab=k_11}
N 54090 330 54060 330 {lab=k_11}
N 6760 890 6800 890 {lab=k_12}
N 6760 890 6760 90 {lab=k_12}
N 6800 890 6800 920 {lab=k_12}
N 6800 920 7070 920 {lab=k_12}
N 7070 920 7070 860 {lab=k_12}
N 7070 920 7080 920 {lab=k_12}
N 7070 860 7160 860 {lab=k_12}
N 7160 860 7160 920 {lab=k_12}
N 7160 920 7440 920 {lab=k_12}
N 6760 90 6800 90 {lab=k_12}
N 6800 90 6800 60 {lab=k_12}
N 6800 60 7070 60 {lab=k_12}
N 7070 60 7080 60 {lab=k_12}
N 7070 60 7070 100 {lab=k_12}
N 7070 100 7160 100 {lab=k_12}
N 7160 100 7160 60 {lab=k_12}
N 7160 60 7430 60 {lab=k_12}
N 7430 60 7440 60 {lab=k_12}
N 7430 60 7430 -40 {lab=k_12}
N 7430 -40 54110 -40 {lab=k_12}
N 54110 -40 54110 370 {lab=k_12}
N 54110 370 54060 370 {lab=k_12}
N 46920 920 46910 920 {lab=k10_ff.net4}
N 46910 920 46910 60 {lab=k10_ff.net4}
N 46910 920 46910 1000 {lab=k10_ff.net4}
N 46910 60 46920 60 {lab=k10_ff.net4}
N 46910 1000 1390 1000 {lab=k10_ff.net4}
N 1390 1000 1390 920 {lab=k10_ff.net4}
N 1390 920 1390 740 {lab=k10_ff.net4}
N 1390 920 1400 920 {lab=k10_ff.net4}
N 1390 740 1390 90 {lab=k10_ff.net4}
N 1390 740 880 740 {lab=k10_ff.net4}
N 1390 90 1080 90 {lab=k10_ff.net4}
N 1390 90 1390 60 {lab=k10_ff.net4}
N 1390 60 1400 60 {lab=k10_ff.net4}
N 1080 90 1080 100 {lab=k10_ff.net4}
N 1080 100 880 100 {lab=k10_ff.net4}
N 880 100 880 90 {lab=k10_ff.net4}
N 10080 890 10120 890 {lab=k_13}
N 10080 890 10080 90 {lab=k_13}
N 10120 890 10120 920 {lab=k_13}
N 10120 920 10390 920 {lab=k_13}
N 10390 920 10400 920 {lab=k_13}
N 10390 920 10390 860 {lab=k_13}
N 10390 860 10480 860 {lab=k_13}
N 10480 860 10480 920 {lab=k_13}
N 10480 920 10750 920 {lab=k_13}
N 10750 920 10750 1020 {lab=k_13}
N 10750 920 10760 920 {lab=k_13}
N 10080 90 10120 90 {lab=k_13}
N 10120 90 10120 60 {lab=k_13}
N 10120 60 10390 60 {lab=k_13}
N 10390 60 10400 60 {lab=k_13}
N 10390 60 10390 100 {lab=k_13}
N 10390 100 10480 100 {lab=k_13}
N 10480 100 10480 60 {lab=k_13}
N 10480 60 10760 60 {lab=k_13}
N 10750 1020 53540 1020 {lab=k_13}
N 53540 1020 53540 410 {lab=k_13}
N 53540 410 54060 410 {lab=k_13}
N 13400 890 13400 90 {lab=k_14}
N 13400 890 13440 890 {lab=k_14}
N 13440 890 13440 920 {lab=k_14}
N 13440 920 13710 920 {lab=k_14}
N 13710 920 13710 860 {lab=k_14}
N 13710 920 13720 920 {lab=k_14}
N 13710 860 13800 860 {lab=k_14}
N 13800 860 13800 920 {lab=k_14}
N 13800 920 14070 920 {lab=k_14}
N 14070 920 14070 1040 {lab=k_14}
N 14070 920 14080 920 {lab=k_14}
N 13400 90 13440 90 {lab=k_14}
N 13440 90 13440 60 {lab=k_14}
N 13440 60 13710 60 {lab=k_14}
N 13710 60 13710 100 {lab=k_14}
N 13710 60 13720 60 {lab=k_14}
N 13710 100 13800 100 {lab=k_14}
N 13800 100 13800 60 {lab=k_14}
N 13800 60 14080 60 {lab=k_14}
N 14070 1040 53560 1040 {lab=k_14}
N 53560 1040 53560 450 {lab=k_14}
N 53560 450 54060 450 {lab=k_14}
N 19320 890 19320 90 {lab=k_1}
N 19320 890 19360 890 {lab=k_1}
N 19360 890 19360 920 {lab=k_1}
N 19360 920 19630 920 {lab=k_1}
N 19630 920 19630 860 {lab=k_1}
N 19630 920 19640 920 {lab=k_1}
N 19630 860 19720 860 {lab=k_1}
N 19720 860 19720 920 {lab=k_1}
N 19720 920 19990 920 {lab=k_1}
N 19990 920 19990 1060 {lab=k_1}
N 19990 920 20000 920 {lab=k_1}
N 19320 90 19360 90 {lab=k_1}
N 19360 90 19360 60 {lab=k_1}
N 19360 60 19630 60 {lab=k_1}
N 19630 60 19630 100 {lab=k_1}
N 19630 60 19640 60 {lab=k_1}
N 19630 100 19720 100 {lab=k_1}
N 19720 100 19720 60 {lab=k_1}
N 19720 60 20000 60 {lab=k_1}
N 19990 1060 53580 1060 {lab=k_1}
N 53580 1060 53580 530 {lab=k_1}
N 53580 530 54060 530 {lab=k_1}
N 52320 920 52310 920 {lab=k1_ff.net4}
N 52310 920 52310 1080 {lab=k1_ff.net4}
N 52310 920 52310 60 {lab=k1_ff.net4}
N 52310 60 52320 60 {lab=k1_ff.net4}
N 52310 1080 19270 1080 {lab=k1_ff.net4}
N 19270 1080 19270 920 {lab=k1_ff.net4}
N 19270 920 19280 920 {lab=k1_ff.net4}
N 19270 920 19270 740 {lab=k1_ff.net4}
N 19270 740 19270 90 {lab=k1_ff.net4}
N 19270 740 18760 740 {lab=k1_ff.net4}
N 19270 90 19270 60 {lab=k1_ff.net4}
N 19270 90 18960 90 {lab=k1_ff.net4}
N 19270 60 19280 60 {lab=k1_ff.net4}
N 18960 90 18960 100 {lab=k1_ff.net4}
N 18960 100 18760 100 {lab=k1_ff.net4}
N 18760 100 18760 90 {lab=k1_ff.net4}
N 21320 890 21360 890 {lab=k_2}
N 21320 890 21320 90 {lab=k_2}
N 21360 890 21360 920 {lab=k_2}
N 21360 920 21630 920 {lab=k_2}
N 21630 920 21640 920 {lab=k_2}
N 21630 920 21630 860 {lab=k_2}
N 21630 860 21720 860 {lab=k_2}
N 21720 860 21720 920 {lab=k_2}
N 21720 920 21990 920 {lab=k_2}
N 21990 920 21990 1100 {lab=k_2}
N 21990 920 22000 920 {lab=k_2}
N 21320 90 21360 90 {lab=k_2}
N 21360 90 21360 60 {lab=k_2}
N 21360 60 21630 60 {lab=k_2}
N 21630 60 21640 60 {lab=k_2}
N 21630 60 21630 100 {lab=k_2}
N 21630 100 21720 100 {lab=k_2}
N 21720 100 21720 60 {lab=k_2}
N 21720 60 22000 60 {lab=k_2}
N 21990 1100 53600 1100 {lab=k_2}
N 53600 1100 53600 570 {lab=k_2}
N 53600 570 54060 570 {lab=k_2}
N 24640 890 24640 90 {lab=k_3}
N 24640 890 24680 890 {lab=k_3}
N 24680 890 24680 920 {lab=k_3}
N 24680 920 24950 920 {lab=k_3}
N 24950 920 24950 860 {lab=k_3}
N 24950 920 24960 920 {lab=k_3}
N 24950 860 25040 860 {lab=k_3}
N 25040 860 25040 920 {lab=k_3}
N 25040 920 25310 920 {lab=k_3}
N 25310 920 25310 1120 {lab=k_3}
N 25310 920 25320 920 {lab=k_3}
N 24640 90 24680 90 {lab=k_3}
N 24680 90 24680 60 {lab=k_3}
N 24680 60 24950 60 {lab=k_3}
N 24950 60 24950 100 {lab=k_3}
N 24950 60 24960 60 {lab=k_3}
N 24950 100 25040 100 {lab=k_3}
N 25040 100 25040 60 {lab=k_3}
N 25040 60 25320 60 {lab=k_3}
N 25310 1120 53620 1120 {lab=k_3}
N 53620 1120 53620 610 {lab=k_3}
N 53620 610 54060 610 {lab=k_3}
N 27960 890 27960 90 {lab=k_4}
N 27960 890 28000 890 {lab=k_4}
N 28000 890 28000 920 {lab=k_4}
N 28000 920 28270 920 {lab=k_4}
N 28270 920 28270 860 {lab=k_4}
N 28270 920 28280 920 {lab=k_4}
N 28270 860 28360 860 {lab=k_4}
N 28360 860 28360 920 {lab=k_4}
N 28360 920 28630 920 {lab=k_4}
N 28630 920 28640 920 {lab=k_4}
N 28630 920 28630 1140 {lab=k_4}
N 27960 90 28000 90 {lab=k_4}
N 28000 90 28000 60 {lab=k_4}
N 28000 60 28270 60 {lab=k_4}
N 28270 60 28270 100 {lab=k_4}
N 28270 60 28280 60 {lab=k_4}
N 28270 100 28360 100 {lab=k_4}
N 28360 100 28360 60 {lab=k_4}
N 28360 60 28640 60 {lab=k_4}
N 28630 1140 53720 1140 {lab=k_4}
N 53720 1140 53720 650 {lab=k_4}
N 53720 650 54060 650 {lab=k_4}
N 31280 890 31320 890 {lab=k_5}
N 31280 890 31280 90 {lab=k_5}
N 31320 890 31320 920 {lab=k_5}
N 31320 920 31590 920 {lab=k_5}
N 31590 920 31600 920 {lab=k_5}
N 31590 920 31590 860 {lab=k_5}
N 31590 860 31680 860 {lab=k_5}
N 31680 860 31680 920 {lab=k_5}
N 31680 920 31950 920 {lab=k_5}
N 31950 920 31950 1160 {lab=k_5}
N 31950 920 31960 920 {lab=k_5}
N 31280 90 31320 90 {lab=k_5}
N 31320 90 31320 60 {lab=k_5}
N 31320 60 31590 60 {lab=k_5}
N 31590 60 31590 100 {lab=k_5}
N 31590 60 31600 60 {lab=k_5}
N 31590 100 31680 100 {lab=k_5}
N 31680 100 31680 60 {lab=k_5}
N 31680 60 31960 60 {lab=k_5}
N 31950 1160 53740 1160 {lab=k_5}
N 53740 1160 53740 690 {lab=k_5}
N 53740 690 54060 690 {lab=k_5}
N 34600 890 34640 890 {lab=k_6}
N 34600 890 34600 90 {lab=k_6}
N 34640 890 34640 920 {lab=k_6}
N 34640 920 34910 920 {lab=k_6}
N 34910 920 34920 920 {lab=k_6}
N 34910 920 34910 860 {lab=k_6}
N 34910 860 35000 860 {lab=k_6}
N 35000 860 35000 920 {lab=k_6}
N 35000 920 35270 920 {lab=k_6}
N 35270 920 35270 1180 {lab=k_6}
N 35270 920 35280 920 {lab=k_6}
N 34600 90 34640 90 {lab=k_6}
N 34640 90 34640 60 {lab=k_6}
N 34640 60 34910 60 {lab=k_6}
N 34910 60 34910 100 {lab=k_6}
N 34910 60 34920 60 {lab=k_6}
N 34910 100 35000 100 {lab=k_6}
N 35000 100 35000 60 {lab=k_6}
N 35000 60 35280 60 {lab=k_6}
N 35270 1180 53760 1180 {lab=k_6}
N 53760 1180 53760 730 {lab=k_6}
N 53760 730 54060 730 {lab=k_6}
N 37920 890 37920 90 {lab=k_7}
N 37920 890 37960 890 {lab=k_7}
N 37960 890 37960 920 {lab=k_7}
N 37960 920 38230 920 {lab=k_7}
N 38230 920 38230 860 {lab=k_7}
N 38230 920 38240 920 {lab=k_7}
N 38230 860 38320 860 {lab=k_7}
N 38320 860 38320 920 {lab=k_7}
N 38320 920 38590 920 {lab=k_7}
N 38590 920 38600 920 {lab=k_7}
N 38590 920 38590 1200 {lab=k_7}
N 37920 90 37960 90 {lab=k_7}
N 37960 90 37960 60 {lab=k_7}
N 37960 60 38230 60 {lab=k_7}
N 38230 60 38230 100 {lab=k_7}
N 38230 60 38240 60 {lab=k_7}
N 38230 100 38320 100 {lab=k_7}
N 38320 100 38320 60 {lab=k_7}
N 38320 60 38600 60 {lab=k_7}
N 38590 1200 53780 1200 {lab=k_7}
N 53780 1200 53780 770 {lab=k_7}
N 53780 770 54060 770 {lab=k_7}
N 41240 890 41280 890 {lab=k_8}
N 41240 890 41240 90 {lab=k_8}
N 41280 890 41280 920 {lab=k_8}
N 41280 920 41550 920 {lab=k_8}
N 41550 920 41560 920 {lab=k_8}
N 41550 920 41550 860 {lab=k_8}
N 41550 860 41640 860 {lab=k_8}
N 41640 860 41640 920 {lab=k_8}
N 41640 920 41910 920 {lab=k_8}
N 41910 920 41910 810 {lab=k_8}
N 41910 920 41920 920 {lab=k_8}
N 41240 90 41280 90 {lab=k_8}
N 41280 90 41280 60 {lab=k_8}
N 41280 60 41550 60 {lab=k_8}
N 41550 60 41550 100 {lab=k_8}
N 41550 60 41560 60 {lab=k_8}
N 41550 100 41640 100 {lab=k_8}
N 41640 100 41640 60 {lab=k_8}
N 41640 60 41920 60 {lab=k_8}
N 41910 810 54060 810 {lab=k_8}
N 44880 920 44870 920 {lab=k_9}
N 44870 920 44600 920 {lab=k_9}
N 44870 920 44870 860 {lab=k_9}
N 44600 920 44600 890 {lab=k_9}
N 44600 890 44560 890 {lab=k_9}
N 44870 860 45320 860 {lab=k_9}
N 44870 860 44870 110 {lab=k_9}
N 45320 860 45320 920 {lab=k_9}
N 45320 920 45590 920 {lab=k_9}
N 45590 920 45590 840 {lab=k_9}
N 45590 920 45600 920 {lab=k_9}
N 44870 110 44870 90 {lab=k_9}
N 44870 110 45320 110 {lab=k_9}
N 44870 90 44560 90 {lab=k_9}
N 44870 90 44870 60 {lab=k_9}
N 44870 60 44880 60 {lab=k_9}
N 45320 110 45320 60 {lab=k_9}
N 45320 60 45600 60 {lab=k_9}
N 45590 840 54060 840 {lab=k_9}
N 54060 840 54060 850 {lab=k_9}
N 53640 920 53520 920 {lab=k0_ff.net4}
N 53520 920 53520 760 {lab=k0_ff.net4}
N 53520 920 53520 1000 {lab=k0_ff.net4}
N 53520 760 53500 760 {lab=k0_ff.net4}
N 53500 760 53500 400 {lab=k0_ff.net4}
N 53500 400 53540 400 {lab=k0_ff.net4}
N 53540 400 53540 60 {lab=k0_ff.net4}
N 53540 60 53640 60 {lab=k0_ff.net4}
N 53520 1000 49150 1000 {lab=k0_ff.net4}
N 49150 1000 49150 920 {lab=k0_ff.net4}
N 49150 920 49160 920 {lab=k0_ff.net4}
N 49150 920 49150 740 {lab=k0_ff.net4}
N 49150 740 48640 740 {lab=k0_ff.net4}
N 49150 740 49150 90 {lab=k0_ff.net4}
N 49150 90 48840 90 {lab=k0_ff.net4}
N 49150 90 49150 60 {lab=k0_ff.net4}
N 49150 60 49160 60 {lab=k0_ff.net4}
N 48840 90 48840 100 {lab=k0_ff.net4}
N 48840 100 48640 100 {lab=k0_ff.net4}
N 48640 100 48640 90 {lab=k0_ff.net4}
N 48240 920 48230 920 {lab=k9_ff.net4}
N 48230 920 48230 860 {lab=k9_ff.net4}
N 48230 860 45570 860 {lab=k9_ff.net4}
N 48230 860 48230 60 {lab=k9_ff.net4}
N 48230 60 48240 60 {lab=k9_ff.net4}
N 45570 860 45570 840 {lab=k9_ff.net4}
N 45570 840 44510 840 {lab=k9_ff.net4}
N 44510 840 44510 740 {lab=k9_ff.net4}
N 44510 840 44510 920 {lab=k9_ff.net4}
N 44510 920 44520 920 {lab=k9_ff.net4}
N 44510 740 44000 740 {lab=k9_ff.net4}
N 44510 740 44510 90 {lab=k9_ff.net4}
N 44510 90 44200 90 {lab=k9_ff.net4}
N 44510 90 44510 60 {lab=k9_ff.net4}
N 44510 60 44520 60 {lab=k9_ff.net4}
N 44200 90 44200 100 {lab=k9_ff.net4}
N 44200 100 44000 100 {lab=k9_ff.net4}
N 44000 100 44000 90 {lab=k9_ff.net4}
N 5800 920 5790 920 {lab=k11_ff.net4}
N 5790 920 5790 840 {lab=k11_ff.net4}
N 5790 840 3390 840 {lab=k11_ff.net4}
N 5790 840 5790 60 {lab=k11_ff.net4}
N 5790 60 5800 60 {lab=k11_ff.net4}
N 3390 840 3390 920 {lab=k11_ff.net4}
N 3390 840 3390 740 {lab=k11_ff.net4}
N 3390 920 3400 920 {lab=k11_ff.net4}
N 3390 740 2880 740 {lab=k11_ff.net4}
N 3390 740 3390 90 {lab=k11_ff.net4}
N 3390 90 3390 60 {lab=k11_ff.net4}
N 3390 90 3080 90 {lab=k11_ff.net4}
N 3390 60 3400 60 {lab=k11_ff.net4}
N 3080 90 3080 100 {lab=k11_ff.net4}
N 3080 100 2880 100 {lab=k11_ff.net4}
N 2880 100 2880 90 {lab=k11_ff.net4}
N 9120 920 9110 920 {lab=k12_ff.net4}
N 9110 920 9110 840 {lab=k12_ff.net4}
N 9110 840 6710 840 {lab=k12_ff.net4}
N 9110 840 9110 60 {lab=k12_ff.net4}
N 9110 60 9120 60 {lab=k12_ff.net4}
N 6710 840 6710 920 {lab=k12_ff.net4}
N 6710 840 6710 740 {lab=k12_ff.net4}
N 6710 920 6720 920 {lab=k12_ff.net4}
N 6710 740 6200 740 {lab=k12_ff.net4}
N 6710 740 6710 90 {lab=k12_ff.net4}
N 6710 90 6400 90 {lab=k12_ff.net4}
N 6710 90 6710 60 {lab=k12_ff.net4}
N 6710 60 6720 60 {lab=k12_ff.net4}
N 6400 90 6400 100 {lab=k12_ff.net4}
N 6400 100 6200 100 {lab=k12_ff.net4}
N 6200 100 6200 90 {lab=k12_ff.net4}
N 12440 920 12430 920 {lab=k13_ff.net4}
N 12430 920 12430 840 {lab=k13_ff.net4}
N 12430 840 10030 840 {lab=k13_ff.net4}
N 12430 840 12430 60 {lab=k13_ff.net4}
N 12430 60 12440 60 {lab=k13_ff.net4}
N 10030 840 10030 740 {lab=k13_ff.net4}
N 10030 840 10030 920 {lab=k13_ff.net4}
N 10030 920 10040 920 {lab=k13_ff.net4}
N 10030 740 9520 740 {lab=k13_ff.net4}
N 10030 740 10030 90 {lab=k13_ff.net4}
N 10030 90 9720 90 {lab=k13_ff.net4}
N 10030 90 10030 60 {lab=k13_ff.net4}
N 10030 60 10040 60 {lab=k13_ff.net4}
N 9720 90 9720 100 {lab=k13_ff.net4}
N 9720 100 9520 100 {lab=k13_ff.net4}
N 9520 100 9520 90 {lab=k13_ff.net4}
N 15760 920 15750 920 {lab=k14_ff.net4}
N 15750 920 15750 840 {lab=k14_ff.net4}
N 15750 840 13350 840 {lab=k14_ff.net4}
N 15750 840 15750 60 {lab=k14_ff.net4}
N 15750 60 15760 60 {lab=k14_ff.net4}
N 13350 840 13350 740 {lab=k14_ff.net4}
N 13350 840 13350 920 {lab=k14_ff.net4}
N 13350 920 13360 920 {lab=k14_ff.net4}
N 13350 740 12840 740 {lab=k14_ff.net4}
N 13350 740 13350 90 {lab=k14_ff.net4}
N 13350 90 13040 90 {lab=k14_ff.net4}
N 13350 90 13350 60 {lab=k14_ff.net4}
N 13350 60 13360 60 {lab=k14_ff.net4}
N 13040 90 13040 100 {lab=k14_ff.net4}
N 13040 100 12840 100 {lab=k14_ff.net4}
N 12840 100 12840 90 {lab=k14_ff.net4}
N 23680 920 23670 920 {lab=k2_ff.net4}
N 23670 920 23670 840 {lab=k2_ff.net4}
N 23670 840 21270 840 {lab=k2_ff.net4}
N 23670 840 23670 60 {lab=k2_ff.net4}
N 23670 60 23680 60 {lab=k2_ff.net4}
N 21270 840 21270 740 {lab=k2_ff.net4}
N 21270 840 21270 920 {lab=k2_ff.net4}
N 21270 920 21280 920 {lab=k2_ff.net4}
N 21270 740 20760 740 {lab=k2_ff.net4}
N 21270 740 21270 90 {lab=k2_ff.net4}
N 21270 90 20960 90 {lab=k2_ff.net4}
N 21270 90 21270 60 {lab=k2_ff.net4}
N 21270 60 21280 60 {lab=k2_ff.net4}
N 20960 90 20960 100 {lab=k2_ff.net4}
N 20960 100 20760 100 {lab=k2_ff.net4}
N 20760 100 20760 90 {lab=k2_ff.net4}
N 27000 920 26990 920 {lab=k3_ff.net4}
N 26990 920 26990 840 {lab=k3_ff.net4}
N 26990 840 24590 840 {lab=k3_ff.net4}
N 26990 840 26990 60 {lab=k3_ff.net4}
N 26990 60 27000 60 {lab=k3_ff.net4}
N 24590 840 24590 740 {lab=k3_ff.net4}
N 24590 840 24590 920 {lab=k3_ff.net4}
N 24590 920 24600 920 {lab=k3_ff.net4}
N 24590 740 24080 740 {lab=k3_ff.net4}
N 24590 740 24590 90 {lab=k3_ff.net4}
N 24590 90 24590 60 {lab=k3_ff.net4}
N 24590 90 24280 90 {lab=k3_ff.net4}
N 24590 60 24600 60 {lab=k3_ff.net4}
N 24280 90 24280 100 {lab=k3_ff.net4}
N 24280 100 24080 100 {lab=k3_ff.net4}
N 24080 100 24080 90 {lab=k3_ff.net4}
N 30320 920 30310 920 {lab=k4_ff.net4}
N 30310 920 30310 840 {lab=k4_ff.net4}
N 30310 840 30310 60 {lab=k4_ff.net4}
N 30310 840 27910 840 {lab=k4_ff.net4}
N 30310 60 30320 60 {lab=k4_ff.net4}
N 27910 840 27910 920 {lab=k4_ff.net4}
N 27910 840 27910 740 {lab=k4_ff.net4}
N 27910 920 27920 920 {lab=k4_ff.net4}
N 27910 740 27910 90 {lab=k4_ff.net4}
N 27910 740 27400 740 {lab=k4_ff.net4}
N 27910 90 27600 90 {lab=k4_ff.net4}
N 27910 90 27910 60 {lab=k4_ff.net4}
N 27910 60 27920 60 {lab=k4_ff.net4}
N 27600 90 27600 100 {lab=k4_ff.net4}
N 27600 100 27400 100 {lab=k4_ff.net4}
N 27400 100 27400 90 {lab=k4_ff.net4}
N 33640 920 33630 920 {lab=k5_ff.net4}
N 33630 920 33630 840 {lab=k5_ff.net4}
N 33630 840 31230 840 {lab=k5_ff.net4}
N 33630 840 33630 60 {lab=k5_ff.net4}
N 33630 60 33640 60 {lab=k5_ff.net4}
N 31230 840 31230 920 {lab=k5_ff.net4}
N 31230 840 31230 740 {lab=k5_ff.net4}
N 31230 920 31240 920 {lab=k5_ff.net4}
N 31230 740 31230 90 {lab=k5_ff.net4}
N 31230 740 30720 740 {lab=k5_ff.net4}
N 31230 90 30920 90 {lab=k5_ff.net4}
N 31230 90 31230 60 {lab=k5_ff.net4}
N 31230 60 31240 60 {lab=k5_ff.net4}
N 30920 90 30920 100 {lab=k5_ff.net4}
N 30920 100 30720 100 {lab=k5_ff.net4}
N 30720 100 30720 90 {lab=k5_ff.net4}
N 36960 920 36950 920 {lab=k6_ff.net4}
N 36950 920 36950 840 {lab=k6_ff.net4}
N 36950 840 34550 840 {lab=k6_ff.net4}
N 36950 840 36950 60 {lab=k6_ff.net4}
N 36950 60 36960 60 {lab=k6_ff.net4}
N 34550 840 34550 740 {lab=k6_ff.net4}
N 34550 840 34550 920 {lab=k6_ff.net4}
N 34550 920 34560 920 {lab=k6_ff.net4}
N 34550 740 34040 740 {lab=k6_ff.net4}
N 34550 740 34550 90 {lab=k6_ff.net4}
N 34550 90 34550 60 {lab=k6_ff.net4}
N 34550 90 34240 90 {lab=k6_ff.net4}
N 34550 60 34560 60 {lab=k6_ff.net4}
N 34240 90 34240 100 {lab=k6_ff.net4}
N 34240 100 34040 100 {lab=k6_ff.net4}
N 34040 100 34040 90 {lab=k6_ff.net4}
N 40280 920 40270 920 {lab=k7_ff.net4}
N 40270 920 40270 840 {lab=k7_ff.net4}
N 40270 840 40270 60 {lab=k7_ff.net4}
N 40270 840 37870 840 {lab=k7_ff.net4}
N 40270 60 40280 60 {lab=k7_ff.net4}
N 37870 840 37870 740 {lab=k7_ff.net4}
N 37870 840 37870 920 {lab=k7_ff.net4}
N 37870 920 37880 920 {lab=k7_ff.net4}
N 37870 740 37360 740 {lab=k7_ff.net4}
N 37870 740 37870 90 {lab=k7_ff.net4}
N 37870 90 37870 60 {lab=k7_ff.net4}
N 37870 90 37560 90 {lab=k7_ff.net4}
N 37870 60 37880 60 {lab=k7_ff.net4}
N 37560 90 37560 100 {lab=k7_ff.net4}
N 37560 100 37360 100 {lab=k7_ff.net4}
N 37360 100 37360 90 {lab=k7_ff.net4}
N 43600 920 43590 920 {lab=k8_ff.net4}
N 43590 920 43590 840 {lab=k8_ff.net4}
N 43590 840 43590 60 {lab=k8_ff.net4}
N 43590 840 41190 840 {lab=k8_ff.net4}
N 43590 60 43600 60 {lab=k8_ff.net4}
N 41190 840 41190 920 {lab=k8_ff.net4}
N 41190 840 41190 740 {lab=k8_ff.net4}
N 41190 920 41200 920 {lab=k8_ff.net4}
N 41190 740 41190 90 {lab=k8_ff.net4}
N 41190 740 40680 740 {lab=k8_ff.net4}
N 41190 90 40880 90 {lab=k8_ff.net4}
N 41190 90 41190 60 {lab=k8_ff.net4}
N 41190 60 41200 60 {lab=k8_ff.net4}
N 40880 90 40880 100 {lab=k8_ff.net4}
N 40880 100 40680 100 {lab=k8_ff.net4}
N 40680 100 40680 90 {lab=k8_ff.net4}
N 18360 920 18350 920 {lab=k15_ff.net4}
N 18350 920 18350 860 {lab=k15_ff.net4}
N 18350 860 16670 860 {lab=k15_ff.net4}
N 18350 860 18350 60 {lab=k15_ff.net4}
N 18350 60 18360 60 {lab=k15_ff.net4}
N 16670 860 16670 740 {lab=k15_ff.net4}
N 16670 860 16670 920 {lab=k15_ff.net4}
N 16670 920 16680 920 {lab=k15_ff.net4}
N 16670 740 16160 740 {lab=k15_ff.net4}
N 16670 740 16670 90 {lab=k15_ff.net4}
N 16670 90 16360 90 {lab=k15_ff.net4}
N 16670 90 16670 60 {lab=k15_ff.net4}
N 16670 60 16680 60 {lab=k15_ff.net4}
N 16360 90 16360 100 {lab=k15_ff.net4}
N 16360 100 16160 100 {lab=k15_ff.net4}
N 16160 100 16160 90 {lab=k15_ff.net4}
N 520 890 520 90 {lab=k0_ff.cki}
N 520 90 560 90 {lab=k0_ff.cki}
N 560 90 560 -60 {lab=k0_ff.cki}
N 560 -60 52400 -60 {lab=k0_ff.cki}
N 52400 -60 52400 770 {lab=k0_ff.cki}
N 52400 770 52670 770 {lab=k0_ff.cki}
N 52670 770 52670 710 {lab=k0_ff.cki}
N 52670 770 52680 770 {lab=k0_ff.cki}
N 52670 710 53070 710 {lab=k0_ff.cki}
N 53070 710 53070 270 {lab=k0_ff.cki}
N 53070 710 53630 710 {lab=k0_ff.cki}
N 53630 710 53630 770 {lab=k0_ff.cki}
N 53630 770 53640 770 {lab=k0_ff.cki}
N 53070 270 53070 210 {lab=k0_ff.cki}
N 53070 270 53160 270 {lab=k0_ff.cki}
N 53070 210 53080 210 {lab=k0_ff.cki}
N 53160 270 53160 210 {lab=k0_ff.cki}
N 53160 210 53440 210 {lab=k0_ff.cki}
N 46760 740 46760 710 {lab=k10_ff.net8}
N 46760 710 46960 710 {lab=k10_ff.net8}
N 46760 710 46760 250 {lab=k10_ff.net8}
N 46960 710 46960 740 {lab=k10_ff.net8}
N 46760 250 46960 250 {lab=k10_ff.net8}
N 46760 250 46710 250 {lab=k10_ff.net8}
N 46760 250 46760 240 {lab=k10_ff.net8}
N 46960 250 46960 240 {lab=k10_ff.net8}
N 46710 250 46710 -80 {lab=k10_ff.net8}
N 46710 -80 1030 -80 {lab=k10_ff.net8}
N 1030 -80 1030 60 {lab=k10_ff.net8}
N 1030 -80 810 -80 {lab=k10_ff.net8}
N 810 -80 810 770 {lab=k10_ff.net8}
N 810 770 840 770 {lab=k10_ff.net8}
N 1030 60 1040 60 {lab=k10_ff.net8}
N 52160 740 52160 710 {lab=k1_ff.net8}
N 52160 710 52360 710 {lab=k1_ff.net8}
N 52160 710 52160 270 {lab=k1_ff.net8}
N 52360 710 52360 740 {lab=k1_ff.net8}
N 52160 270 52360 270 {lab=k1_ff.net8}
N 52160 270 52110 270 {lab=k1_ff.net8}
N 52160 270 52160 240 {lab=k1_ff.net8}
N 52360 270 52360 240 {lab=k1_ff.net8}
N 52110 270 52110 -100 {lab=k1_ff.net8}
N 52110 -100 18910 -100 {lab=k1_ff.net8}
N 18910 -100 18690 -100 {lab=k1_ff.net8}
N 18910 -100 18910 60 {lab=k1_ff.net8}
N 18690 -100 18690 770 {lab=k1_ff.net8}
N 18690 770 18720 770 {lab=k1_ff.net8}
N 18910 60 18920 60 {lab=k1_ff.net8}
N 42320 890 42320 700 {lab=k9_ff.cki}
N 42320 700 46280 700 {lab=k9_ff.cki}
N 42320 700 42320 90 {lab=k9_ff.cki}
N 46280 700 46280 690 {lab=k9_ff.cki}
N 46280 690 47000 690 {lab=k9_ff.cki}
N 47000 690 47000 770 {lab=k9_ff.cki}
N 47000 770 47270 770 {lab=k9_ff.cki}
N 47270 770 47280 770 {lab=k9_ff.cki}
N 47270 770 47270 710 {lab=k9_ff.cki}
N 47270 710 47670 710 {lab=k9_ff.cki}
N 47670 710 48140 710 {lab=k9_ff.cki}
N 47670 710 47670 250 {lab=k9_ff.cki}
N 48140 710 48140 770 {lab=k9_ff.cki}
N 48140 770 48240 770 {lab=k9_ff.cki}
N 47670 250 47760 250 {lab=k9_ff.cki}
N 47670 250 47670 210 {lab=k9_ff.cki}
N 47670 210 47680 210 {lab=k9_ff.cki}
N 47760 250 47760 210 {lab=k9_ff.cki}
N 47760 210 48040 210 {lab=k9_ff.cki}
N 53480 740 53480 690 {lab=k0_ff.net8}
N 53480 690 53680 690 {lab=k0_ff.net8}
N 53480 690 48790 690 {lab=k0_ff.net8}
N 53480 690 53480 270 {lab=k0_ff.net8}
N 53680 690 53680 740 {lab=k0_ff.net8}
N 53480 270 53480 240 {lab=k0_ff.net8}
N 53480 270 53680 270 {lab=k0_ff.net8}
N 53680 270 53680 240 {lab=k0_ff.net8}
N 48790 690 48790 60 {lab=k0_ff.net8}
N 48790 690 48570 690 {lab=k0_ff.net8}
N 48570 690 48570 770 {lab=k0_ff.net8}
N 48570 770 48600 770 {lab=k0_ff.net8}
N 48790 60 48800 60 {lab=k0_ff.net8}
N 4520 890 4520 810 {lab=k12_ff.cki}
N 4520 810 6240 810 {lab=k12_ff.cki}
N 4520 810 4520 90 {lab=k12_ff.cki}
N 6240 810 6240 770 {lab=k12_ff.cki}
N 6240 770 8150 770 {lab=k12_ff.cki}
N 8150 770 8160 770 {lab=k12_ff.cki}
N 8150 770 8150 810 {lab=k12_ff.cki}
N 8150 810 8530 810 {lab=k12_ff.cki}
N 8530 810 8530 250 {lab=k12_ff.cki}
N 8530 810 9000 810 {lab=k12_ff.cki}
N 9000 810 9000 770 {lab=k12_ff.cki}
N 9000 770 9120 770 {lab=k12_ff.cki}
N 8530 250 8530 210 {lab=k12_ff.cki}
N 8530 250 8640 250 {lab=k12_ff.cki}
N 8530 210 8560 210 {lab=k12_ff.cki}
N 8640 250 8640 210 {lab=k12_ff.cki}
N 8640 210 8920 210 {lab=k12_ff.cki}
N 7840 890 7840 710 {lab=k13_ff.cki}
N 7840 710 7840 90 {lab=k13_ff.cki}
N 7840 710 10050 710 {lab=k13_ff.cki}
N 10050 710 10050 770 {lab=k13_ff.cki}
N 10050 770 11470 770 {lab=k13_ff.cki}
N 11470 770 11470 810 {lab=k13_ff.cki}
N 11470 770 11480 770 {lab=k13_ff.cki}
N 11470 810 11850 810 {lab=k13_ff.cki}
N 11850 810 12320 810 {lab=k13_ff.cki}
N 11850 810 11850 250 {lab=k13_ff.cki}
N 12320 810 12320 770 {lab=k13_ff.cki}
N 12320 770 12440 770 {lab=k13_ff.cki}
N 11850 250 11960 250 {lab=k13_ff.cki}
N 11850 250 11850 210 {lab=k13_ff.cki}
N 11850 210 11880 210 {lab=k13_ff.cki}
N 11960 250 11960 210 {lab=k13_ff.cki}
N 11960 210 12240 210 {lab=k13_ff.cki}
N 11160 890 11160 710 {lab=k14_ff.cki}
N 11160 710 11160 90 {lab=k14_ff.cki}
N 11160 710 13370 710 {lab=k14_ff.cki}
N 13370 710 13370 770 {lab=k14_ff.cki}
N 13370 770 14790 770 {lab=k14_ff.cki}
N 14790 770 14790 810 {lab=k14_ff.cki}
N 14790 770 14800 770 {lab=k14_ff.cki}
N 14790 810 15170 810 {lab=k14_ff.cki}
N 15170 810 15640 810 {lab=k14_ff.cki}
N 15170 810 15170 250 {lab=k14_ff.cki}
N 15640 810 15640 770 {lab=k14_ff.cki}
N 15640 770 15760 770 {lab=k14_ff.cki}
N 15170 250 15170 210 {lab=k14_ff.cki}
N 15170 250 15280 250 {lab=k14_ff.cki}
N 15170 210 15200 210 {lab=k14_ff.cki}
N 15280 250 15280 210 {lab=k14_ff.cki}
N 15280 210 15560 210 {lab=k14_ff.cki}
N 22400 890 22400 810 {lab=k3_ff.cki}
N 22400 810 22400 90 {lab=k3_ff.cki}
N 22400 810 24120 810 {lab=k3_ff.cki}
N 24120 810 24120 770 {lab=k3_ff.cki}
N 24120 770 26030 770 {lab=k3_ff.cki}
N 26030 770 26030 810 {lab=k3_ff.cki}
N 26030 770 26040 770 {lab=k3_ff.cki}
N 26030 810 26410 810 {lab=k3_ff.cki}
N 26410 810 26880 810 {lab=k3_ff.cki}
N 26410 810 26410 250 {lab=k3_ff.cki}
N 26880 810 26880 770 {lab=k3_ff.cki}
N 26880 770 27000 770 {lab=k3_ff.cki}
N 26410 250 26520 250 {lab=k3_ff.cki}
N 26410 250 26410 210 {lab=k3_ff.cki}
N 26410 210 26440 210 {lab=k3_ff.cki}
N 26520 250 26520 210 {lab=k3_ff.cki}
N 26520 210 26800 210 {lab=k3_ff.cki}
N 25720 890 25720 710 {lab=k4_ff.cki}
N 25720 710 27930 710 {lab=k4_ff.cki}
N 25720 710 25720 90 {lab=k4_ff.cki}
N 27930 710 27930 770 {lab=k4_ff.cki}
N 27930 770 29350 770 {lab=k4_ff.cki}
N 29350 770 29360 770 {lab=k4_ff.cki}
N 29350 770 29350 810 {lab=k4_ff.cki}
N 29350 810 29730 810 {lab=k4_ff.cki}
N 29730 810 29730 250 {lab=k4_ff.cki}
N 29730 810 30200 810 {lab=k4_ff.cki}
N 30200 810 30200 770 {lab=k4_ff.cki}
N 30200 770 30320 770 {lab=k4_ff.cki}
N 29730 250 29730 210 {lab=k4_ff.cki}
N 29730 250 29840 250 {lab=k4_ff.cki}
N 29730 210 29760 210 {lab=k4_ff.cki}
N 29840 250 29840 210 {lab=k4_ff.cki}
N 29840 210 30120 210 {lab=k4_ff.cki}
N 29040 890 29040 710 {lab=k5_ff.cki}
N 29040 710 31250 710 {lab=k5_ff.cki}
N 29040 710 29040 90 {lab=k5_ff.cki}
N 31250 710 31250 770 {lab=k5_ff.cki}
N 31250 770 32670 770 {lab=k5_ff.cki}
N 32670 770 32680 770 {lab=k5_ff.cki}
N 32670 770 32670 810 {lab=k5_ff.cki}
N 32670 810 33050 810 {lab=k5_ff.cki}
N 33050 810 33050 250 {lab=k5_ff.cki}
N 33050 810 33520 810 {lab=k5_ff.cki}
N 33520 810 33520 770 {lab=k5_ff.cki}
N 33520 770 33640 770 {lab=k5_ff.cki}
N 33050 250 33160 250 {lab=k5_ff.cki}
N 33050 250 33050 210 {lab=k5_ff.cki}
N 33050 210 33080 210 {lab=k5_ff.cki}
N 33160 250 33160 210 {lab=k5_ff.cki}
N 33160 210 33440 210 {lab=k5_ff.cki}
N 32360 890 32360 710 {lab=k6_ff.cki}
N 32360 710 32360 90 {lab=k6_ff.cki}
N 32360 710 34570 710 {lab=k6_ff.cki}
N 34570 710 34570 770 {lab=k6_ff.cki}
N 34570 770 35990 770 {lab=k6_ff.cki}
N 35990 770 35990 810 {lab=k6_ff.cki}
N 35990 770 36000 770 {lab=k6_ff.cki}
N 35990 810 36370 810 {lab=k6_ff.cki}
N 36370 810 36840 810 {lab=k6_ff.cki}
N 36370 810 36370 250 {lab=k6_ff.cki}
N 36840 810 36840 770 {lab=k6_ff.cki}
N 36840 770 36960 770 {lab=k6_ff.cki}
N 36370 250 36480 250 {lab=k6_ff.cki}
N 36370 250 36370 210 {lab=k6_ff.cki}
N 36370 210 36400 210 {lab=k6_ff.cki}
N 36480 250 36480 210 {lab=k6_ff.cki}
N 36480 210 36760 210 {lab=k6_ff.cki}
N 35680 890 35680 710 {lab=k7_ff.cki}
N 35680 710 37890 710 {lab=k7_ff.cki}
N 35680 710 35680 90 {lab=k7_ff.cki}
N 37890 710 37890 770 {lab=k7_ff.cki}
N 37890 770 39310 770 {lab=k7_ff.cki}
N 39310 770 39310 810 {lab=k7_ff.cki}
N 39310 770 39320 770 {lab=k7_ff.cki}
N 39310 810 39690 810 {lab=k7_ff.cki}
N 39690 810 39690 250 {lab=k7_ff.cki}
N 39690 810 40160 810 {lab=k7_ff.cki}
N 40160 810 40160 770 {lab=k7_ff.cki}
N 40160 770 40280 770 {lab=k7_ff.cki}
N 39690 250 39800 250 {lab=k7_ff.cki}
N 39690 250 39690 210 {lab=k7_ff.cki}
N 39690 210 39720 210 {lab=k7_ff.cki}
N 39800 250 39800 210 {lab=k7_ff.cki}
N 39800 210 40080 210 {lab=k7_ff.cki}
N 39000 890 39000 710 {lab=k8_ff.cki}
N 39000 710 41210 710 {lab=k8_ff.cki}
N 39000 710 39000 90 {lab=k8_ff.cki}
N 41210 710 41210 770 {lab=k8_ff.cki}
N 41210 770 42630 770 {lab=k8_ff.cki}
N 42630 770 42640 770 {lab=k8_ff.cki}
N 42630 770 42630 860 {lab=k8_ff.cki}
N 42630 860 43010 860 {lab=k8_ff.cki}
N 43010 860 43010 250 {lab=k8_ff.cki}
N 43010 860 43480 860 {lab=k8_ff.cki}
N 43480 860 43480 770 {lab=k8_ff.cki}
N 43480 770 43600 770 {lab=k8_ff.cki}
N 43010 250 43120 250 {lab=k8_ff.cki}
N 43010 250 43010 210 {lab=k8_ff.cki}
N 43010 210 43040 210 {lab=k8_ff.cki}
N 43120 250 43120 210 {lab=k8_ff.cki}
N 43120 210 43400 210 {lab=k8_ff.cki}
N 48080 740 48160 740 {lab=k9_ff.net8}
N 48080 740 48080 580 {lab=k9_ff.net8}
N 48160 740 48160 730 {lab=k9_ff.net8}
N 48160 730 48280 730 {lab=k9_ff.net8}
N 48280 730 48280 740 {lab=k9_ff.net8}
N 48080 580 48080 250 {lab=k9_ff.net8}
N 48080 580 44150 580 {lab=k9_ff.net8}
N 48080 250 48080 240 {lab=k9_ff.net8}
N 48080 250 48280 250 {lab=k9_ff.net8}
N 48280 250 48280 240 {lab=k9_ff.net8}
N 44150 580 43930 580 {lab=k9_ff.net8}
N 44150 580 44150 60 {lab=k9_ff.net8}
N 43930 580 43930 770 {lab=k9_ff.net8}
N 43930 770 43960 770 {lab=k9_ff.net8}
N 44150 60 44160 60 {lab=k9_ff.net8}
N 14480 890 14480 710 {lab=k15_ff.cki}
N 14480 710 16690 710 {lab=k15_ff.cki}
N 14480 710 14480 90 {lab=k15_ff.cki}
N 16690 710 16690 770 {lab=k15_ff.cki}
N 16690 770 17390 770 {lab=k15_ff.cki}
N 17390 770 17390 810 {lab=k15_ff.cki}
N 17390 770 17400 770 {lab=k15_ff.cki}
N 17390 810 17770 810 {lab=k15_ff.cki}
N 17770 810 18240 810 {lab=k15_ff.cki}
N 17770 810 17770 250 {lab=k15_ff.cki}
N 18240 810 18240 770 {lab=k15_ff.cki}
N 18240 770 18360 770 {lab=k15_ff.cki}
N 17770 250 17880 250 {lab=k15_ff.cki}
N 17770 250 17770 210 {lab=k15_ff.cki}
N 17770 210 17800 210 {lab=k15_ff.cki}
N 17880 250 17880 210 {lab=k15_ff.cki}
N 17880 210 18160 210 {lab=k15_ff.cki}
N 2520 890 2520 810 {lab=k11_ff.cki}
N 2520 810 2520 90 {lab=k11_ff.cki}
N 2520 810 2920 810 {lab=k11_ff.cki}
N 2920 810 2920 770 {lab=k11_ff.cki}
N 2920 770 4830 770 {lab=k11_ff.cki}
N 4830 770 4830 710 {lab=k11_ff.cki}
N 4830 770 4840 770 {lab=k11_ff.cki}
N 4830 710 5210 710 {lab=k11_ff.cki}
N 5210 710 5210 250 {lab=k11_ff.cki}
N 5210 710 5700 710 {lab=k11_ff.cki}
N 5700 710 5700 770 {lab=k11_ff.cki}
N 5700 770 5800 770 {lab=k11_ff.cki}
N 5210 250 5320 250 {lab=k11_ff.cki}
N 5210 250 5210 210 {lab=k11_ff.cki}
N 5210 210 5240 210 {lab=k11_ff.cki}
N 5320 250 5320 210 {lab=k11_ff.cki}
N 5320 210 5600 210 {lab=k11_ff.cki}
N 20400 890 20400 810 {lab=k2_ff.cki}
N 20400 810 20800 810 {lab=k2_ff.cki}
N 20400 810 20400 90 {lab=k2_ff.cki}
N 20800 810 20800 770 {lab=k2_ff.cki}
N 20800 770 22710 770 {lab=k2_ff.cki}
N 22710 770 22720 770 {lab=k2_ff.cki}
N 22710 770 22710 710 {lab=k2_ff.cki}
N 22710 710 23090 710 {lab=k2_ff.cki}
N 23090 710 23580 710 {lab=k2_ff.cki}
N 23090 710 23090 250 {lab=k2_ff.cki}
N 23580 710 23580 770 {lab=k2_ff.cki}
N 23580 770 23680 770 {lab=k2_ff.cki}
N 23090 250 23200 250 {lab=k2_ff.cki}
N 23090 250 23090 210 {lab=k2_ff.cki}
N 23090 210 23120 210 {lab=k2_ff.cki}
N 23200 250 23200 210 {lab=k2_ff.cki}
N 23200 210 23480 210 {lab=k2_ff.cki}
N 5640 740 5720 740 {lab=k11_ff.net8}
N 5640 740 5640 580 {lab=k11_ff.net8}
N 5720 740 5720 730 {lab=k11_ff.net8}
N 5720 730 5840 730 {lab=k11_ff.net8}
N 5840 730 5840 740 {lab=k11_ff.net8}
N 5640 580 3030 580 {lab=k11_ff.net8}
N 5640 580 5640 250 {lab=k11_ff.net8}
N 5640 250 5840 250 {lab=k11_ff.net8}
N 5640 250 5640 240 {lab=k11_ff.net8}
N 5840 250 5840 240 {lab=k11_ff.net8}
N 3030 580 3030 60 {lab=k11_ff.net8}
N 3030 580 2810 580 {lab=k11_ff.net8}
N 2810 580 2810 770 {lab=k11_ff.net8}
N 2810 770 2840 770 {lab=k11_ff.net8}
N 3030 60 3040 60 {lab=k11_ff.net8}
N 8960 740 9040 740 {lab=k12_ff.net8}
N 8960 740 8960 690 {lab=k12_ff.net8}
N 9040 740 9040 730 {lab=k12_ff.net8}
N 9040 730 9160 730 {lab=k12_ff.net8}
N 9160 730 9160 740 {lab=k12_ff.net8}
N 8960 690 6350 690 {lab=k12_ff.net8}
N 8960 690 8960 250 {lab=k12_ff.net8}
N 8960 250 8960 240 {lab=k12_ff.net8}
N 8960 250 9160 250 {lab=k12_ff.net8}
N 9160 250 9160 240 {lab=k12_ff.net8}
N 6350 690 6130 690 {lab=k12_ff.net8}
N 6350 690 6350 60 {lab=k12_ff.net8}
N 6130 690 6130 770 {lab=k12_ff.net8}
N 6130 770 6160 770 {lab=k12_ff.net8}
N 6350 60 6360 60 {lab=k12_ff.net8}
N 12280 740 12280 690 {lab=k13_ff.net8}
N 12280 740 12360 740 {lab=k13_ff.net8}
N 12360 740 12360 730 {lab=k13_ff.net8}
N 12360 730 12480 730 {lab=k13_ff.net8}
N 12480 730 12480 740 {lab=k13_ff.net8}
N 12280 690 9670 690 {lab=k13_ff.net8}
N 12280 690 12280 250 {lab=k13_ff.net8}
N 12280 250 12480 250 {lab=k13_ff.net8}
N 12280 250 12280 240 {lab=k13_ff.net8}
N 12480 250 12480 240 {lab=k13_ff.net8}
N 9670 690 9450 690 {lab=k13_ff.net8}
N 9670 690 9670 60 {lab=k13_ff.net8}
N 9450 690 9450 770 {lab=k13_ff.net8}
N 9450 770 9480 770 {lab=k13_ff.net8}
N 9670 60 9680 60 {lab=k13_ff.net8}
N 15600 740 15600 690 {lab=k14_ff.net8}
N 15600 740 15680 740 {lab=k14_ff.net8}
N 15680 740 15680 730 {lab=k14_ff.net8}
N 15680 730 15800 730 {lab=k14_ff.net8}
N 15800 730 15800 740 {lab=k14_ff.net8}
N 15600 690 12990 690 {lab=k14_ff.net8}
N 15600 690 15600 250 {lab=k14_ff.net8}
N 15600 250 15800 250 {lab=k14_ff.net8}
N 15600 250 15600 240 {lab=k14_ff.net8}
N 15800 250 15800 240 {lab=k14_ff.net8}
N 12990 690 12770 690 {lab=k14_ff.net8}
N 12990 690 12990 60 {lab=k14_ff.net8}
N 12770 690 12770 770 {lab=k14_ff.net8}
N 12770 770 12800 770 {lab=k14_ff.net8}
N 12990 60 13000 60 {lab=k14_ff.net8}
N 23520 740 23520 580 {lab=k2_ff.net8}
N 23520 740 23600 740 {lab=k2_ff.net8}
N 23600 740 23600 730 {lab=k2_ff.net8}
N 23600 730 23720 730 {lab=k2_ff.net8}
N 23720 730 23720 740 {lab=k2_ff.net8}
N 23520 580 20910 580 {lab=k2_ff.net8}
N 23520 580 23520 250 {lab=k2_ff.net8}
N 23520 250 23520 240 {lab=k2_ff.net8}
N 23520 250 23720 250 {lab=k2_ff.net8}
N 23720 250 23720 240 {lab=k2_ff.net8}
N 20910 580 20910 60 {lab=k2_ff.net8}
N 20910 580 20690 580 {lab=k2_ff.net8}
N 20690 580 20690 770 {lab=k2_ff.net8}
N 20690 770 20720 770 {lab=k2_ff.net8}
N 20910 60 20920 60 {lab=k2_ff.net8}
N 26840 740 26920 740 {lab=k3_ff.net8}
N 26840 740 26840 690 {lab=k3_ff.net8}
N 26920 740 26920 730 {lab=k3_ff.net8}
N 26920 730 27040 730 {lab=k3_ff.net8}
N 27040 730 27040 740 {lab=k3_ff.net8}
N 26840 690 24230 690 {lab=k3_ff.net8}
N 26840 690 26840 250 {lab=k3_ff.net8}
N 26840 250 27040 250 {lab=k3_ff.net8}
N 26840 250 26840 240 {lab=k3_ff.net8}
N 27040 250 27040 240 {lab=k3_ff.net8}
N 24230 690 24010 690 {lab=k3_ff.net8}
N 24230 690 24230 60 {lab=k3_ff.net8}
N 24010 690 24010 770 {lab=k3_ff.net8}
N 24010 770 24040 770 {lab=k3_ff.net8}
N 24230 60 24240 60 {lab=k3_ff.net8}
N 30160 740 30240 740 {lab=k4_ff.net8}
N 30160 740 30160 690 {lab=k4_ff.net8}
N 30240 740 30240 730 {lab=k4_ff.net8}
N 30240 730 30360 730 {lab=k4_ff.net8}
N 30360 730 30360 740 {lab=k4_ff.net8}
N 30160 690 27550 690 {lab=k4_ff.net8}
N 30160 690 30160 250 {lab=k4_ff.net8}
N 30160 250 30160 240 {lab=k4_ff.net8}
N 30160 250 30360 250 {lab=k4_ff.net8}
N 30360 250 30360 240 {lab=k4_ff.net8}
N 27550 690 27330 690 {lab=k4_ff.net8}
N 27550 690 27550 60 {lab=k4_ff.net8}
N 27330 690 27330 770 {lab=k4_ff.net8}
N 27330 770 27360 770 {lab=k4_ff.net8}
N 27550 60 27560 60 {lab=k4_ff.net8}
N 33480 740 33480 690 {lab=k5_ff.net8}
N 33480 740 33560 740 {lab=k5_ff.net8}
N 33560 740 33560 730 {lab=k5_ff.net8}
N 33560 730 33680 730 {lab=k5_ff.net8}
N 33680 730 33680 740 {lab=k5_ff.net8}
N 33480 690 33480 250 {lab=k5_ff.net8}
N 33480 690 30870 690 {lab=k5_ff.net8}
N 33480 250 33480 240 {lab=k5_ff.net8}
N 33480 250 33680 250 {lab=k5_ff.net8}
N 33680 250 33680 240 {lab=k5_ff.net8}
N 30870 690 30870 60 {lab=k5_ff.net8}
N 30870 690 30650 690 {lab=k5_ff.net8}
N 30650 690 30650 770 {lab=k5_ff.net8}
N 30650 770 30680 770 {lab=k5_ff.net8}
N 30870 60 30880 60 {lab=k5_ff.net8}
N 36800 740 36800 690 {lab=k6_ff.net8}
N 36800 740 36880 740 {lab=k6_ff.net8}
N 36880 740 36880 730 {lab=k6_ff.net8}
N 36880 730 37000 730 {lab=k6_ff.net8}
N 37000 730 37000 740 {lab=k6_ff.net8}
N 36800 690 34190 690 {lab=k6_ff.net8}
N 36800 690 36800 250 {lab=k6_ff.net8}
N 36800 250 37000 250 {lab=k6_ff.net8}
N 36800 250 36800 240 {lab=k6_ff.net8}
N 37000 250 37000 240 {lab=k6_ff.net8}
N 34190 690 33970 690 {lab=k6_ff.net8}
N 34190 690 34190 60 {lab=k6_ff.net8}
N 33970 690 33970 770 {lab=k6_ff.net8}
N 33970 770 34000 770 {lab=k6_ff.net8}
N 34190 60 34200 60 {lab=k6_ff.net8}
N 40120 740 40200 740 {lab=k7_ff.net8}
N 40120 740 40120 690 {lab=k7_ff.net8}
N 40200 740 40200 730 {lab=k7_ff.net8}
N 40200 730 40320 730 {lab=k7_ff.net8}
N 40320 730 40320 740 {lab=k7_ff.net8}
N 40120 690 37510 690 {lab=k7_ff.net8}
N 40120 690 40120 250 {lab=k7_ff.net8}
N 40120 250 40320 250 {lab=k7_ff.net8}
N 40120 250 40120 240 {lab=k7_ff.net8}
N 40320 250 40320 240 {lab=k7_ff.net8}
N 37510 690 37290 690 {lab=k7_ff.net8}
N 37510 690 37510 60 {lab=k7_ff.net8}
N 37290 690 37290 770 {lab=k7_ff.net8}
N 37290 770 37320 770 {lab=k7_ff.net8}
N 37510 60 37520 60 {lab=k7_ff.net8}
N 43440 740 43490 740 {lab=k8_ff.net8}
N 43440 740 43440 580 {lab=k8_ff.net8}
N 43490 740 43490 730 {lab=k8_ff.net8}
N 43490 730 43640 730 {lab=k8_ff.net8}
N 43640 730 43640 740 {lab=k8_ff.net8}
N 43440 580 43440 250 {lab=k8_ff.net8}
N 43440 580 40830 580 {lab=k8_ff.net8}
N 43440 250 43440 240 {lab=k8_ff.net8}
N 43440 250 43640 250 {lab=k8_ff.net8}
N 43640 250 43640 240 {lab=k8_ff.net8}
N 40830 580 40610 580 {lab=k8_ff.net8}
N 40830 580 40830 60 {lab=k8_ff.net8}
N 40610 580 40610 770 {lab=k8_ff.net8}
N 40610 770 40640 770 {lab=k8_ff.net8}
N 40830 60 40840 60 {lab=k8_ff.net8}
N 52680 920 52650 920 {lab=k0_d}
N 52650 920 52650 860 {lab=k0_d}
N 52650 860 51350 860 {lab=k0_d}
N 52650 860 52650 60 {lab=k0_d}
N 52650 60 52680 60 {lab=k0_d}
N 51350 860 51350 790 {lab=k0_d}
N 51350 790 50320 790 {lab=k0_d}
N 50320 790 50130 790 {lab=k0_d}
N 50320 790 50320 250 {lab=k0_d}
N 50130 790 50130 800 {lab=k0_d}
N 50130 800 50120 800 {lab=k0_d}
N 50130 800 50130 890 {lab=k0_d}
N 50130 890 50120 890 {lab=k0_d}
N 50320 250 50120 250 {lab=k0_d}
N 50320 250 50320 240 {lab=k0_d}
N 50120 250 50120 240 {lab=k0_d}
N 18200 740 18200 710 {lab=k15_ff.net8}
N 18200 710 18400 710 {lab=k15_ff.net8}
N 18200 710 18200 690 {lab=k15_ff.net8}
N 18400 710 18400 740 {lab=k15_ff.net8}
N 18200 690 16310 690 {lab=k15_ff.net8}
N 18200 690 18200 250 {lab=k15_ff.net8}
N 18200 250 18400 250 {lab=k15_ff.net8}
N 18200 250 18200 240 {lab=k15_ff.net8}
N 18400 250 18400 240 {lab=k15_ff.net8}
N 16310 690 16090 690 {lab=k15_ff.net8}
N 16310 690 16310 60 {lab=k15_ff.net8}
N 16090 690 16090 770 {lab=k15_ff.net8}
N 16090 770 16120 770 {lab=k15_ff.net8}
N 16310 60 16320 60 {lab=k15_ff.net8}
N 45280 890 45280 770 {lab=k10_ff.cki}
N 45280 770 45280 90 {lab=k10_ff.cki}
N 45280 770 45950 770 {lab=k10_ff.cki}
N 45950 770 45960 770 {lab=k10_ff.cki}
N 45950 770 45950 720 {lab=k10_ff.cki}
N 45950 720 46350 720 {lab=k10_ff.cki}
N 46350 720 46780 720 {lab=k10_ff.cki}
N 46350 720 46350 250 {lab=k10_ff.cki}
N 46780 720 46780 750 {lab=k10_ff.cki}
N 46780 750 46800 750 {lab=k10_ff.cki}
N 46800 750 46800 770 {lab=k10_ff.cki}
N 46800 770 46920 770 {lab=k10_ff.cki}
N 46350 250 46440 250 {lab=k10_ff.cki}
N 46350 250 46350 210 {lab=k10_ff.cki}
N 46350 210 46360 210 {lab=k10_ff.cki}
N 46440 250 46440 210 {lab=k10_ff.cki}
N 46440 210 46720 210 {lab=k10_ff.cki}
N 51040 890 51040 770 {lab=k1_ff.cki}
N 51040 770 51040 90 {lab=k1_ff.cki}
N 51040 770 51350 770 {lab=k1_ff.cki}
N 51350 770 51360 770 {lab=k1_ff.cki}
N 51350 770 51350 720 {lab=k1_ff.cki}
N 51350 720 51750 720 {lab=k1_ff.cki}
N 51750 720 52180 720 {lab=k1_ff.cki}
N 51750 720 51750 270 {lab=k1_ff.cki}
N 52180 720 52180 750 {lab=k1_ff.cki}
N 52180 750 52200 750 {lab=k1_ff.cki}
N 52200 750 52200 770 {lab=k1_ff.cki}
N 52200 770 52320 770 {lab=k1_ff.cki}
N 51750 270 51840 270 {lab=k1_ff.cki}
N 51750 270 51750 210 {lab=k1_ff.cki}
N 51750 210 51760 210 {lab=k1_ff.cki}
N 51840 270 51840 210 {lab=k1_ff.cki}
N 51840 210 52120 210 {lab=k1_ff.cki}
N 46000 740 46000 560 {lab=k10_ff.net1}
N 46000 560 46000 240 {lab=k10_ff.net1}
N 46000 560 46200 560 {lab=k10_ff.net1}
N 46200 560 46300 560 {lab=k10_ff.net1}
N 46200 560 46200 590 {lab=k10_ff.net1}
N 46300 560 46300 920 {lab=k10_ff.net1}
N 46300 560 46400 560 {lab=k10_ff.net1}
N 46300 920 46720 920 {lab=k10_ff.net1}
N 46400 560 46400 270 {lab=k10_ff.net1}
N 46400 270 46460 270 {lab=k10_ff.net1}
N 46400 270 46400 240 {lab=k10_ff.net1}
N 46460 270 46460 60 {lab=k10_ff.net1}
N 46460 60 46720 60 {lab=k10_ff.net1}
N 4880 740 4880 730 {lab=k11_ff.net1}
N 4880 730 5140 730 {lab=k11_ff.net1}
N 4880 730 4880 560 {lab=k11_ff.net1}
N 4880 560 5080 560 {lab=k11_ff.net1}
N 4880 560 4880 270 {lab=k11_ff.net1}
N 5080 560 5080 590 {lab=k11_ff.net1}
N 4880 270 4880 240 {lab=k11_ff.net1}
N 4880 270 5280 270 {lab=k11_ff.net1}
N 5140 730 5140 920 {lab=k11_ff.net1}
N 5140 920 5600 920 {lab=k11_ff.net1}
N 5280 270 5280 240 {lab=k11_ff.net1}
N 5280 270 5340 270 {lab=k11_ff.net1}
N 5340 270 5340 60 {lab=k11_ff.net1}
N 5340 60 5600 60 {lab=k11_ff.net1}
N 8200 740 8200 580 {lab=k12_ff.net1}
N 8200 580 8200 270 {lab=k12_ff.net1}
N 8200 580 8400 580 {lab=k12_ff.net1}
N 8400 580 8400 590 {lab=k12_ff.net1}
N 8400 590 8460 590 {lab=k12_ff.net1}
N 8200 270 8600 270 {lab=k12_ff.net1}
N 8200 270 8200 240 {lab=k12_ff.net1}
N 8460 590 8460 920 {lab=k12_ff.net1}
N 8460 920 8920 920 {lab=k12_ff.net1}
N 8600 270 8600 240 {lab=k12_ff.net1}
N 8600 270 8660 270 {lab=k12_ff.net1}
N 8660 270 8660 60 {lab=k12_ff.net1}
N 8660 60 8920 60 {lab=k12_ff.net1}
N 11520 740 11520 580 {lab=k13_ff.net1}
N 11520 580 11520 270 {lab=k13_ff.net1}
N 11520 580 11720 580 {lab=k13_ff.net1}
N 11720 580 11720 590 {lab=k13_ff.net1}
N 11720 590 11780 590 {lab=k13_ff.net1}
N 11520 270 11920 270 {lab=k13_ff.net1}
N 11520 270 11520 240 {lab=k13_ff.net1}
N 11780 590 11780 920 {lab=k13_ff.net1}
N 11780 920 12240 920 {lab=k13_ff.net1}
N 11920 270 11980 270 {lab=k13_ff.net1}
N 11920 270 11920 240 {lab=k13_ff.net1}
N 11980 270 11980 60 {lab=k13_ff.net1}
N 11980 60 12240 60 {lab=k13_ff.net1}
N 14840 740 14840 580 {lab=k14_ff.net1}
N 14840 580 15040 580 {lab=k14_ff.net1}
N 14840 580 14840 270 {lab=k14_ff.net1}
N 15040 580 15040 590 {lab=k14_ff.net1}
N 15040 590 15100 590 {lab=k14_ff.net1}
N 14840 270 14840 240 {lab=k14_ff.net1}
N 14840 270 15240 270 {lab=k14_ff.net1}
N 15100 590 15100 920 {lab=k14_ff.net1}
N 15100 920 15560 920 {lab=k14_ff.net1}
N 15240 270 15300 270 {lab=k14_ff.net1}
N 15240 270 15240 240 {lab=k14_ff.net1}
N 15300 270 15300 60 {lab=k14_ff.net1}
N 15300 60 15560 60 {lab=k14_ff.net1}
N 17440 740 17440 580 {lab=k15_ff.net1}
N 17440 580 17440 270 {lab=k15_ff.net1}
N 17440 580 17640 580 {lab=k15_ff.net1}
N 17640 580 17640 590 {lab=k15_ff.net1}
N 17640 590 17700 590 {lab=k15_ff.net1}
N 17440 270 17840 270 {lab=k15_ff.net1}
N 17440 270 17440 240 {lab=k15_ff.net1}
N 17700 590 17700 920 {lab=k15_ff.net1}
N 17700 920 18160 920 {lab=k15_ff.net1}
N 17840 270 17900 270 {lab=k15_ff.net1}
N 17840 270 17840 240 {lab=k15_ff.net1}
N 17900 270 17900 60 {lab=k15_ff.net1}
N 17900 60 18160 60 {lab=k15_ff.net1}
N 51400 740 51400 580 {lab=k1_ff.net1}
N 51400 580 51400 240 {lab=k1_ff.net1}
N 51400 580 51600 580 {lab=k1_ff.net1}
N 51600 580 51600 590 {lab=k1_ff.net1}
N 51600 590 51700 590 {lab=k1_ff.net1}
N 51700 590 51800 590 {lab=k1_ff.net1}
N 51700 590 51700 920 {lab=k1_ff.net1}
N 51700 920 52120 920 {lab=k1_ff.net1}
N 51800 590 51800 290 {lab=k1_ff.net1}
N 51800 290 51860 290 {lab=k1_ff.net1}
N 51800 290 51800 240 {lab=k1_ff.net1}
N 51860 290 51860 60 {lab=k1_ff.net1}
N 51860 60 52120 60 {lab=k1_ff.net1}
N 22760 740 22760 730 {lab=k2_ff.net1}
N 22760 730 22760 560 {lab=k2_ff.net1}
N 22760 730 23020 730 {lab=k2_ff.net1}
N 22760 560 22760 270 {lab=k2_ff.net1}
N 22760 560 22960 560 {lab=k2_ff.net1}
N 22960 560 22960 590 {lab=k2_ff.net1}
N 22760 270 23160 270 {lab=k2_ff.net1}
N 22760 270 22760 240 {lab=k2_ff.net1}
N 23020 730 23020 920 {lab=k2_ff.net1}
N 23020 920 23480 920 {lab=k2_ff.net1}
N 23160 270 23160 240 {lab=k2_ff.net1}
N 23160 270 23220 270 {lab=k2_ff.net1}
N 23220 270 23220 60 {lab=k2_ff.net1}
N 23220 60 23480 60 {lab=k2_ff.net1}
N 26080 740 26080 580 {lab=k3_ff.net1}
N 26080 580 26280 580 {lab=k3_ff.net1}
N 26080 580 26080 270 {lab=k3_ff.net1}
N 26280 580 26280 590 {lab=k3_ff.net1}
N 26280 590 26340 590 {lab=k3_ff.net1}
N 26080 270 26080 240 {lab=k3_ff.net1}
N 26080 270 26480 270 {lab=k3_ff.net1}
N 26340 590 26340 920 {lab=k3_ff.net1}
N 26340 920 26800 920 {lab=k3_ff.net1}
N 26480 270 26540 270 {lab=k3_ff.net1}
N 26480 270 26480 240 {lab=k3_ff.net1}
N 26540 270 26540 60 {lab=k3_ff.net1}
N 26540 60 26800 60 {lab=k3_ff.net1}
N 29400 740 29400 580 {lab=k4_ff.net1}
N 29400 580 29400 270 {lab=k4_ff.net1}
N 29400 580 29600 580 {lab=k4_ff.net1}
N 29600 580 29600 590 {lab=k4_ff.net1}
N 29600 590 29660 590 {lab=k4_ff.net1}
N 29400 270 29800 270 {lab=k4_ff.net1}
N 29400 270 29400 240 {lab=k4_ff.net1}
N 29660 590 29660 920 {lab=k4_ff.net1}
N 29660 920 30120 920 {lab=k4_ff.net1}
N 29800 270 29800 240 {lab=k4_ff.net1}
N 29800 270 29860 270 {lab=k4_ff.net1}
N 29860 270 29860 60 {lab=k4_ff.net1}
N 29860 60 30120 60 {lab=k4_ff.net1}
N 32720 740 32720 580 {lab=k5_ff.net1}
N 32720 580 32720 270 {lab=k5_ff.net1}
N 32720 580 32920 580 {lab=k5_ff.net1}
N 32920 580 32920 590 {lab=k5_ff.net1}
N 32920 590 32980 590 {lab=k5_ff.net1}
N 32720 270 33120 270 {lab=k5_ff.net1}
N 32720 270 32720 240 {lab=k5_ff.net1}
N 32980 590 32980 920 {lab=k5_ff.net1}
N 32980 920 33440 920 {lab=k5_ff.net1}
N 33120 270 33180 270 {lab=k5_ff.net1}
N 33120 270 33120 240 {lab=k5_ff.net1}
N 33180 270 33180 60 {lab=k5_ff.net1}
N 33180 60 33440 60 {lab=k5_ff.net1}
N 36040 740 36040 580 {lab=k6_ff.net1}
N 36040 580 36240 580 {lab=k6_ff.net1}
N 36040 580 36040 270 {lab=k6_ff.net1}
N 36240 580 36240 590 {lab=k6_ff.net1}
N 36240 590 36300 590 {lab=k6_ff.net1}
N 36040 270 36040 240 {lab=k6_ff.net1}
N 36040 270 36440 270 {lab=k6_ff.net1}
N 36300 590 36300 920 {lab=k6_ff.net1}
N 36300 920 36760 920 {lab=k6_ff.net1}
N 36440 270 36500 270 {lab=k6_ff.net1}
N 36440 270 36440 240 {lab=k6_ff.net1}
N 36500 270 36500 60 {lab=k6_ff.net1}
N 36500 60 36760 60 {lab=k6_ff.net1}
N 39360 740 39360 580 {lab=k7_ff.net1}
N 39360 580 39560 580 {lab=k7_ff.net1}
N 39360 580 39360 270 {lab=k7_ff.net1}
N 39560 580 39560 590 {lab=k7_ff.net1}
N 39560 590 39620 590 {lab=k7_ff.net1}
N 39360 270 39360 240 {lab=k7_ff.net1}
N 39360 270 39760 270 {lab=k7_ff.net1}
N 39620 590 39620 920 {lab=k7_ff.net1}
N 39620 920 40080 920 {lab=k7_ff.net1}
N 39760 270 39760 240 {lab=k7_ff.net1}
N 39760 270 39820 270 {lab=k7_ff.net1}
N 39820 270 39820 60 {lab=k7_ff.net1}
N 39820 60 40080 60 {lab=k7_ff.net1}
N 42680 740 42680 730 {lab=k8_ff.net1}
N 42680 730 42940 730 {lab=k8_ff.net1}
N 42680 730 42680 560 {lab=k8_ff.net1}
N 42680 560 42880 560 {lab=k8_ff.net1}
N 42680 560 42680 270 {lab=k8_ff.net1}
N 42880 560 42880 590 {lab=k8_ff.net1}
N 42680 270 43080 270 {lab=k8_ff.net1}
N 42680 270 42680 240 {lab=k8_ff.net1}
N 42940 730 42940 920 {lab=k8_ff.net1}
N 42940 920 43400 920 {lab=k8_ff.net1}
N 43080 270 43080 240 {lab=k8_ff.net1}
N 43080 270 43140 270 {lab=k8_ff.net1}
N 43140 270 43140 60 {lab=k8_ff.net1}
N 43140 60 43400 60 {lab=k8_ff.net1}
N 47320 740 47320 730 {lab=k9_ff.net1}
N 47320 730 47600 730 {lab=k9_ff.net1}
N 47320 730 47320 560 {lab=k9_ff.net1}
N 47320 560 47520 560 {lab=k9_ff.net1}
N 47320 560 47320 270 {lab=k9_ff.net1}
N 47520 560 47520 590 {lab=k9_ff.net1}
N 47320 270 47320 240 {lab=k9_ff.net1}
N 47320 270 47720 270 {lab=k9_ff.net1}
N 47600 730 47600 920 {lab=k9_ff.net1}
N 47600 920 48040 920 {lab=k9_ff.net1}
N 47720 270 47720 240 {lab=k9_ff.net1}
N 47720 270 47780 270 {lab=k9_ff.net1}
N 47780 270 47780 60 {lab=k9_ff.net1}
N 47780 60 48040 60 {lab=k9_ff.net1}
N 52720 740 52720 580 {lab=k0_ff.net1}
N 52720 580 52920 580 {lab=k0_ff.net1}
N 52720 580 52720 240 {lab=k0_ff.net1}
N 52920 580 52920 590 {lab=k0_ff.net1}
N 52920 590 53000 590 {lab=k0_ff.net1}
N 53000 590 53000 920 {lab=k0_ff.net1}
N 53000 590 53120 590 {lab=k0_ff.net1}
N 53000 920 53440 920 {lab=k0_ff.net1}
N 53120 590 53120 290 {lab=k0_ff.net1}
N 53120 290 53180 290 {lab=k0_ff.net1}
N 53120 290 53120 240 {lab=k0_ff.net1}
N 53180 290 53180 60 {lab=k0_ff.net1}
N 53180 60 53440 60 {lab=k0_ff.net1}
N 46160 770 46150 770 {lab=k10_ff.net2}
N 46150 770 46130 770 {lab=k10_ff.net2}
N 46150 770 46150 820 {lab=k10_ff.net2}
N 46150 820 46210 820 {lab=k10_ff.net2}
N 46210 820 46210 790 {lab=k10_ff.net2}
N 46210 790 46710 790 {lab=k10_ff.net2}
N 46710 790 46710 820 {lab=k10_ff.net2}
N 46710 820 46760 820 {lab=k10_ff.net2}
N 46760 820 46760 890 {lab=k10_ff.net2}
N 46760 820 46760 800 {lab=k10_ff.net2}
N 46130 770 46130 170 {lab=k10_ff.net2}
N 46130 170 46760 170 {lab=k10_ff.net2}
N 46130 170 46130 60 {lab=k10_ff.net2}
N 46130 60 46160 60 {lab=k10_ff.net2}
N 46760 170 46760 90 {lab=k10_ff.net2}
N 46760 170 46760 180 {lab=k10_ff.net2}
N 5040 770 5030 770 {lab=k11_ff.net2}
N 5030 770 5010 770 {lab=k11_ff.net2}
N 5030 770 5030 860 {lab=k11_ff.net2}
N 5030 860 5640 860 {lab=k11_ff.net2}
N 5640 860 5640 890 {lab=k11_ff.net2}
N 5640 860 5640 800 {lab=k11_ff.net2}
N 5010 770 5010 170 {lab=k11_ff.net2}
N 5010 170 5010 60 {lab=k11_ff.net2}
N 5010 170 5640 170 {lab=k11_ff.net2}
N 5010 60 5040 60 {lab=k11_ff.net2}
N 5640 170 5640 90 {lab=k11_ff.net2}
N 5640 170 5640 180 {lab=k11_ff.net2}
N 8360 770 8350 770 {lab=k12_ff.net2}
N 8350 770 8350 730 {lab=k12_ff.net2}
N 8350 730 8330 730 {lab=k12_ff.net2}
N 8350 730 8890 730 {lab=k12_ff.net2}
N 8890 730 8890 820 {lab=k12_ff.net2}
N 8890 820 8960 820 {lab=k12_ff.net2}
N 8960 820 8960 800 {lab=k12_ff.net2}
N 8960 820 8960 890 {lab=k12_ff.net2}
N 8330 730 8330 170 {lab=k12_ff.net2}
N 8330 170 8960 170 {lab=k12_ff.net2}
N 8330 170 8330 60 {lab=k12_ff.net2}
N 8330 60 8360 60 {lab=k12_ff.net2}
N 8960 170 8960 180 {lab=k12_ff.net2}
N 8960 170 8960 90 {lab=k12_ff.net2}
N 11680 770 11670 770 {lab=k13_ff.net2}
N 11670 770 11670 730 {lab=k13_ff.net2}
N 11670 730 12210 730 {lab=k13_ff.net2}
N 11670 730 11650 730 {lab=k13_ff.net2}
N 12210 730 12210 820 {lab=k13_ff.net2}
N 12210 820 12280 820 {lab=k13_ff.net2}
N 12280 820 12280 890 {lab=k13_ff.net2}
N 12280 820 12280 800 {lab=k13_ff.net2}
N 11650 730 11650 170 {lab=k13_ff.net2}
N 11650 170 12280 170 {lab=k13_ff.net2}
N 11650 170 11650 60 {lab=k13_ff.net2}
N 11650 60 11680 60 {lab=k13_ff.net2}
N 12280 170 12280 90 {lab=k13_ff.net2}
N 12280 170 12280 180 {lab=k13_ff.net2}
N 15000 770 14990 770 {lab=k14_ff.net2}
N 14990 770 14990 730 {lab=k14_ff.net2}
N 14990 730 15530 730 {lab=k14_ff.net2}
N 14990 730 14970 730 {lab=k14_ff.net2}
N 15530 730 15530 820 {lab=k14_ff.net2}
N 15530 820 15600 820 {lab=k14_ff.net2}
N 15600 820 15600 890 {lab=k14_ff.net2}
N 15600 820 15600 800 {lab=k14_ff.net2}
N 14970 730 14970 170 {lab=k14_ff.net2}
N 14970 170 14970 60 {lab=k14_ff.net2}
N 14970 170 15600 170 {lab=k14_ff.net2}
N 14970 60 15000 60 {lab=k14_ff.net2}
N 15600 170 15600 180 {lab=k14_ff.net2}
N 15600 170 15600 90 {lab=k14_ff.net2}
N 17600 770 17590 770 {lab=k15_ff.net2}
N 17590 770 17570 770 {lab=k15_ff.net2}
N 17590 770 17590 830 {lab=k15_ff.net2}
N 17590 830 18200 830 {lab=k15_ff.net2}
N 18200 830 18200 890 {lab=k15_ff.net2}
N 18200 830 18200 800 {lab=k15_ff.net2}
N 17570 770 17570 170 {lab=k15_ff.net2}
N 17570 170 18200 170 {lab=k15_ff.net2}
N 17570 170 17570 60 {lab=k15_ff.net2}
N 17570 60 17600 60 {lab=k15_ff.net2}
N 18200 170 18200 90 {lab=k15_ff.net2}
N 18200 170 18200 180 {lab=k15_ff.net2}
N 51560 770 51550 770 {lab=k1_ff.net2}
N 51550 770 51530 770 {lab=k1_ff.net2}
N 51550 770 51550 820 {lab=k1_ff.net2}
N 51550 820 51610 820 {lab=k1_ff.net2}
N 51610 820 51610 790 {lab=k1_ff.net2}
N 51610 790 52110 790 {lab=k1_ff.net2}
N 52110 790 52110 820 {lab=k1_ff.net2}
N 52110 820 52160 820 {lab=k1_ff.net2}
N 52160 820 52160 800 {lab=k1_ff.net2}
N 52160 820 52160 890 {lab=k1_ff.net2}
N 51530 770 51530 170 {lab=k1_ff.net2}
N 51530 170 52160 170 {lab=k1_ff.net2}
N 51530 170 51530 60 {lab=k1_ff.net2}
N 51530 60 51560 60 {lab=k1_ff.net2}
N 52160 170 52160 90 {lab=k1_ff.net2}
N 52160 170 52160 180 {lab=k1_ff.net2}
N 22920 770 22910 770 {lab=k2_ff.net2}
N 22910 770 22890 770 {lab=k2_ff.net2}
N 22910 770 22910 860 {lab=k2_ff.net2}
N 22910 860 23520 860 {lab=k2_ff.net2}
N 23520 860 23520 800 {lab=k2_ff.net2}
N 23520 860 23520 890 {lab=k2_ff.net2}
N 22890 770 22890 170 {lab=k2_ff.net2}
N 22890 170 23520 170 {lab=k2_ff.net2}
N 22890 170 22890 60 {lab=k2_ff.net2}
N 22890 60 22920 60 {lab=k2_ff.net2}
N 23520 170 23520 90 {lab=k2_ff.net2}
N 23520 170 23520 180 {lab=k2_ff.net2}
N 26240 770 26230 770 {lab=k3_ff.net2}
N 26230 770 26230 730 {lab=k3_ff.net2}
N 26230 730 26770 730 {lab=k3_ff.net2}
N 26230 730 26210 730 {lab=k3_ff.net2}
N 26770 730 26770 820 {lab=k3_ff.net2}
N 26770 820 26840 820 {lab=k3_ff.net2}
N 26840 820 26840 890 {lab=k3_ff.net2}
N 26840 820 26840 800 {lab=k3_ff.net2}
N 26210 730 26210 170 {lab=k3_ff.net2}
N 26210 170 26210 60 {lab=k3_ff.net2}
N 26210 170 26840 170 {lab=k3_ff.net2}
N 26210 60 26240 60 {lab=k3_ff.net2}
N 26840 170 26840 90 {lab=k3_ff.net2}
N 26840 170 26840 180 {lab=k3_ff.net2}
N 29560 770 29550 770 {lab=k4_ff.net2}
N 29550 770 29550 730 {lab=k4_ff.net2}
N 29550 730 30090 730 {lab=k4_ff.net2}
N 29550 730 29530 730 {lab=k4_ff.net2}
N 30090 730 30090 820 {lab=k4_ff.net2}
N 30090 820 30160 820 {lab=k4_ff.net2}
N 30160 820 30160 800 {lab=k4_ff.net2}
N 30160 820 30160 890 {lab=k4_ff.net2}
N 29530 730 29530 170 {lab=k4_ff.net2}
N 29530 170 29530 60 {lab=k4_ff.net2}
N 29530 170 30160 170 {lab=k4_ff.net2}
N 29530 60 29560 60 {lab=k4_ff.net2}
N 30160 170 30160 180 {lab=k4_ff.net2}
N 30160 170 30160 90 {lab=k4_ff.net2}
N 32880 770 32870 770 {lab=k5_ff.net2}
N 32870 770 32870 730 {lab=k5_ff.net2}
N 32870 730 33410 730 {lab=k5_ff.net2}
N 32870 730 32850 730 {lab=k5_ff.net2}
N 33410 730 33410 820 {lab=k5_ff.net2}
N 33410 820 33480 820 {lab=k5_ff.net2}
N 33480 820 33480 800 {lab=k5_ff.net2}
N 33480 820 33480 890 {lab=k5_ff.net2}
N 32850 730 32850 170 {lab=k5_ff.net2}
N 32850 170 33480 170 {lab=k5_ff.net2}
N 32850 170 32850 60 {lab=k5_ff.net2}
N 32850 60 32880 60 {lab=k5_ff.net2}
N 33480 170 33480 180 {lab=k5_ff.net2}
N 33480 170 33480 90 {lab=k5_ff.net2}
N 36200 770 36190 770 {lab=k6_ff.net2}
N 36190 770 36190 730 {lab=k6_ff.net2}
N 36190 730 36730 730 {lab=k6_ff.net2}
N 36190 730 36170 730 {lab=k6_ff.net2}
N 36730 730 36730 820 {lab=k6_ff.net2}
N 36730 820 36800 820 {lab=k6_ff.net2}
N 36800 820 36800 890 {lab=k6_ff.net2}
N 36800 820 36800 800 {lab=k6_ff.net2}
N 36170 730 36170 170 {lab=k6_ff.net2}
N 36170 170 36170 60 {lab=k6_ff.net2}
N 36170 170 36800 170 {lab=k6_ff.net2}
N 36170 60 36200 60 {lab=k6_ff.net2}
N 36800 170 36800 90 {lab=k6_ff.net2}
N 36800 170 36800 180 {lab=k6_ff.net2}
N 39520 770 39510 770 {lab=k7_ff.net2}
N 39510 770 39510 730 {lab=k7_ff.net2}
N 39510 730 40050 730 {lab=k7_ff.net2}
N 39510 730 39490 730 {lab=k7_ff.net2}
N 40050 730 40050 820 {lab=k7_ff.net2}
N 40050 820 40120 820 {lab=k7_ff.net2}
N 40120 820 40120 800 {lab=k7_ff.net2}
N 40120 820 40120 890 {lab=k7_ff.net2}
N 39490 730 39490 170 {lab=k7_ff.net2}
N 39490 170 39490 60 {lab=k7_ff.net2}
N 39490 170 40120 170 {lab=k7_ff.net2}
N 39490 60 39520 60 {lab=k7_ff.net2}
N 40120 170 40120 90 {lab=k7_ff.net2}
N 40120 170 40120 180 {lab=k7_ff.net2}
N 42840 770 42830 770 {lab=k8_ff.net2}
N 42830 770 42830 820 {lab=k8_ff.net2}
N 42830 770 42810 770 {lab=k8_ff.net2}
N 42830 820 42890 820 {lab=k8_ff.net2}
N 42890 820 42890 790 {lab=k8_ff.net2}
N 42890 790 43390 790 {lab=k8_ff.net2}
N 43390 790 43390 820 {lab=k8_ff.net2}
N 43390 820 43440 820 {lab=k8_ff.net2}
N 43440 820 43440 800 {lab=k8_ff.net2}
N 43440 820 43440 890 {lab=k8_ff.net2}
N 42810 770 42810 170 {lab=k8_ff.net2}
N 42810 170 42810 60 {lab=k8_ff.net2}
N 42810 170 43440 170 {lab=k8_ff.net2}
N 42810 60 42840 60 {lab=k8_ff.net2}
N 43440 170 43440 180 {lab=k8_ff.net2}
N 43440 170 43440 90 {lab=k8_ff.net2}
N 47480 770 47470 770 {lab=k9_ff.net2}
N 47470 770 47470 820 {lab=k9_ff.net2}
N 47470 770 47450 770 {lab=k9_ff.net2}
N 47470 820 47530 820 {lab=k9_ff.net2}
N 47530 820 47530 790 {lab=k9_ff.net2}
N 47530 790 48030 790 {lab=k9_ff.net2}
N 48030 790 48030 820 {lab=k9_ff.net2}
N 48030 820 48080 820 {lab=k9_ff.net2}
N 48080 820 48080 800 {lab=k9_ff.net2}
N 48080 820 48080 890 {lab=k9_ff.net2}
N 47450 770 47450 170 {lab=k9_ff.net2}
N 47450 170 47450 60 {lab=k9_ff.net2}
N 47450 170 48080 170 {lab=k9_ff.net2}
N 47450 60 47480 60 {lab=k9_ff.net2}
N 48080 170 48080 180 {lab=k9_ff.net2}
N 48080 170 48080 90 {lab=k9_ff.net2}
N 52880 770 52870 770 {lab=k0_ff.net2}
N 52870 770 52870 860 {lab=k0_ff.net2}
N 52870 770 52850 770 {lab=k0_ff.net2}
N 52870 860 53480 860 {lab=k0_ff.net2}
N 53480 860 53480 890 {lab=k0_ff.net2}
N 53480 860 53480 800 {lab=k0_ff.net2}
N 52850 770 52850 170 {lab=k0_ff.net2}
N 52850 170 52850 60 {lab=k0_ff.net2}
N 52850 170 53480 170 {lab=k0_ff.net2}
N 52850 60 52880 60 {lab=k0_ff.net2}
N 53480 170 53480 90 {lab=k0_ff.net2}
N 53480 170 53480 180 {lab=k0_ff.net2}
N 49520 920 49490 920 {lab=event_bit}
N 49490 920 49490 730 {lab=event_bit}
N 49490 730 50160 730 {lab=event_bit}
N 49490 730 49490 210 {lab=event_bit}
N 49490 210 49490 -120 {lab=event_bit}
N 49490 210 49520 210 {lab=event_bit}
N 50160 730 50160 210 {lab=event_bit}
N 50160 730 50160 920 {lab=event_bit}
N 50160 920 50280 920 {lab=event_bit}
N 50160 210 50280 210 {lab=event_bit}
N 49490 -120 -60 -120 {lab=event_bit}
N -60 -120 -60 510 {lab=event_bit}
N 16720 890 16720 90 {lab=k_15}
N 16720 890 16760 890 {lab=k_15}
N 16760 890 16760 920 {lab=k_15}
N 16760 920 17040 920 {lab=k_15}
N 16720 90 16760 90 {lab=k_15}
N 16760 90 16760 60 {lab=k_15}
N 16760 60 17030 60 {lab=k_15}
N 17030 60 17040 60 {lab=k_15}
N 17030 60 17030 -140 {lab=k_15}
N 17030 -140 54130 -140 {lab=k_15}
N 54130 -140 54130 490 {lab=k_15}
N 54130 490 54060 490 {lab=k_15}
N 49560 890 49560 790 {lab=k0_xor.I}
N 49560 790 49560 240 {lab=k0_xor.I}
N 49560 790 49760 790 {lab=k0_xor.I}
N 49760 790 49760 890 {lab=k0_xor.I}
N 49760 890 49800 890 {lab=k0_xor.I}
N 49800 890 49800 920 {lab=k0_xor.I}
N 49800 920 50080 920 {lab=k0_xor.I}
N 49560 240 49600 240 {lab=k0_xor.I}
N 49600 240 49600 60 {lab=k0_xor.I}
N 49600 60 50080 60 {lab=k0_xor.I}
N 45960 920 45930 920 {lab=k_n_10}
N 45930 920 45930 1220 {lab=k_n_10}
N 45930 920 45930 60 {lab=k_n_10}
N 45930 60 45960 60 {lab=k_n_10}
N 45930 1220 1860 1220 {lab=k_n_10}
N 1860 1220 1860 890 {lab=k_n_10}
N 1860 890 1800 890 {lab=k_n_10}
N 1800 890 1800 90 {lab=k_n_10}
N 51360 920 51330 920 {lab=k_n_1}
N 51330 920 51330 1240 {lab=k_n_1}
N 51330 920 51330 60 {lab=k_n_1}
N 51330 60 51360 60 {lab=k_n_1}
N 51330 1240 19740 1240 {lab=k_n_1}
N 19740 1240 19740 890 {lab=k_n_1}
N 19740 890 19680 890 {lab=k_n_1}
N 19680 890 19680 90 {lab=k_n_1}
N 47280 920 47250 920 {lab=k_n_9}
N 47250 920 47250 540 {lab=k_n_9}
N 47250 540 47250 60 {lab=k_n_9}
N 47250 540 45640 540 {lab=k_n_9}
N 47250 60 47280 60 {lab=k_n_9}
N 45640 540 45640 90 {lab=k_n_9}
N 45640 540 45640 890 {lab=k_n_9}
N 4840 920 4810 920 {lab=k_n_11}
N 4810 920 4810 790 {lab=k_n_11}
N 4810 790 3800 790 {lab=k_n_11}
N 4810 790 4810 60 {lab=k_n_11}
N 4810 60 4840 60 {lab=k_n_11}
N 3800 790 3800 890 {lab=k_n_11}
N 3800 790 3800 90 {lab=k_n_11}
N 8160 920 8130 920 {lab=k_n_12}
N 8130 920 8130 820 {lab=k_n_12}
N 8130 820 7120 820 {lab=k_n_12}
N 8130 820 8130 60 {lab=k_n_12}
N 8130 60 8160 60 {lab=k_n_12}
N 7120 820 7120 90 {lab=k_n_12}
N 7120 820 7120 890 {lab=k_n_12}
N 11480 920 11450 920 {lab=k_n_13}
N 11450 920 11450 820 {lab=k_n_13}
N 11450 820 11450 60 {lab=k_n_13}
N 11450 820 10440 820 {lab=k_n_13}
N 11450 60 11480 60 {lab=k_n_13}
N 10440 820 10440 890 {lab=k_n_13}
N 10440 820 10440 90 {lab=k_n_13}
N 14800 920 14770 920 {lab=k_n_14}
N 14770 920 14770 820 {lab=k_n_14}
N 14770 820 13760 820 {lab=k_n_14}
N 14770 820 14770 60 {lab=k_n_14}
N 14770 60 14800 60 {lab=k_n_14}
N 13760 820 13760 890 {lab=k_n_14}
N 13760 820 13760 90 {lab=k_n_14}
N 22720 920 22690 920 {lab=k_n_2}
N 22690 920 22690 790 {lab=k_n_2}
N 22690 790 21680 790 {lab=k_n_2}
N 22690 790 22690 60 {lab=k_n_2}
N 22690 60 22720 60 {lab=k_n_2}
N 21680 790 21680 90 {lab=k_n_2}
N 21680 790 21680 890 {lab=k_n_2}
N 26040 920 26010 920 {lab=k_n_3}
N 26010 920 26010 820 {lab=k_n_3}
N 26010 820 25000 820 {lab=k_n_3}
N 26010 820 26010 60 {lab=k_n_3}
N 26010 60 26040 60 {lab=k_n_3}
N 25000 820 25000 90 {lab=k_n_3}
N 25000 820 25000 890 {lab=k_n_3}
N 29360 920 29330 920 {lab=k_n_4}
N 29330 920 29330 820 {lab=k_n_4}
N 29330 820 28320 820 {lab=k_n_4}
N 29330 820 29330 60 {lab=k_n_4}
N 29330 60 29360 60 {lab=k_n_4}
N 28320 820 28320 90 {lab=k_n_4}
N 28320 820 28320 890 {lab=k_n_4}
N 32680 920 32650 920 {lab=k_n_5}
N 32650 920 32650 820 {lab=k_n_5}
N 32650 820 31640 820 {lab=k_n_5}
N 32650 820 32650 60 {lab=k_n_5}
N 32650 60 32680 60 {lab=k_n_5}
N 31640 820 31640 890 {lab=k_n_5}
N 31640 820 31640 90 {lab=k_n_5}
N 36000 920 35970 920 {lab=k_n_6}
N 35970 920 35970 820 {lab=k_n_6}
N 35970 820 34960 820 {lab=k_n_6}
N 35970 820 35970 60 {lab=k_n_6}
N 35970 60 36000 60 {lab=k_n_6}
N 34960 820 34960 90 {lab=k_n_6}
N 34960 820 34960 890 {lab=k_n_6}
N 39320 920 39290 920 {lab=k_n_7}
N 39290 920 39290 820 {lab=k_n_7}
N 39290 820 38280 820 {lab=k_n_7}
N 39290 820 39290 60 {lab=k_n_7}
N 39290 60 39320 60 {lab=k_n_7}
N 38280 820 38280 90 {lab=k_n_7}
N 38280 820 38280 890 {lab=k_n_7}
N 42640 920 42610 920 {lab=k_n_8}
N 42610 920 42610 790 {lab=k_n_8}
N 42610 790 41600 790 {lab=k_n_8}
N 42610 790 42610 60 {lab=k_n_8}
N 42610 60 42640 60 {lab=k_n_8}
N 41600 790 41600 90 {lab=k_n_8}
N 41600 790 41600 890 {lab=k_n_8}
N 17400 920 17370 920 {lab=k_n_15}
N 17370 920 17120 920 {lab=k_n_15}
N 17370 920 17370 90 {lab=k_n_15}
N 17120 920 17120 890 {lab=k_n_15}
N 17120 890 17080 890 {lab=k_n_15}
N 17370 90 17370 60 {lab=k_n_15}
N 17370 90 17080 90 {lab=k_n_15}
N 17370 60 17400 60 {lab=k_n_15}
N 46000 890 46000 800 {lab=k10_ff.net6}
N 46000 800 46040 800 {lab=k10_ff.net6}
N 46040 800 46040 180 {lab=k10_ff.net6}
N 46040 180 46000 180 {lab=k10_ff.net6}
N 46000 180 46000 90 {lab=k10_ff.net6}
N 46960 800 47020 800 {lab=k10_ff.net11}
N 46960 800 46960 890 {lab=k10_ff.net11}
N 47020 800 47020 180 {lab=k10_ff.net11}
N 47020 180 46960 180 {lab=k10_ff.net11}
N 46960 180 46960 90 {lab=k10_ff.net11}
N 4880 890 4880 800 {lab=k11_ff.net6}
N 4880 800 4920 800 {lab=k11_ff.net6}
N 4920 800 4920 180 {lab=k11_ff.net6}
N 4920 180 4880 180 {lab=k11_ff.net6}
N 4880 180 4880 90 {lab=k11_ff.net6}
N 5840 800 5840 830 {lab=k11_ff.net11}
N 5840 830 5880 830 {lab=k11_ff.net11}
N 5840 830 5840 890 {lab=k11_ff.net11}
N 5880 830 5880 180 {lab=k11_ff.net11}
N 5880 180 5840 180 {lab=k11_ff.net11}
N 5840 180 5840 90 {lab=k11_ff.net11}
N 8200 890 8200 800 {lab=k12_ff.net6}
N 8200 800 8240 800 {lab=k12_ff.net6}
N 8240 800 8240 180 {lab=k12_ff.net6}
N 8240 180 8200 180 {lab=k12_ff.net6}
N 8200 180 8200 90 {lab=k12_ff.net6}
N 9160 800 9200 800 {lab=k12_ff.net11}
N 9160 800 9160 890 {lab=k12_ff.net11}
N 9200 800 9200 180 {lab=k12_ff.net11}
N 9200 180 9160 180 {lab=k12_ff.net11}
N 9160 180 9160 90 {lab=k12_ff.net11}
N 11520 890 11520 800 {lab=k13_ff.net6}
N 11520 800 11560 800 {lab=k13_ff.net6}
N 11560 800 11560 180 {lab=k13_ff.net6}
N 11560 180 11520 180 {lab=k13_ff.net6}
N 11520 180 11520 90 {lab=k13_ff.net6}
N 12480 800 12520 800 {lab=k13_ff.net11}
N 12480 800 12480 890 {lab=k13_ff.net11}
N 12520 800 12520 180 {lab=k13_ff.net11}
N 12520 180 12480 180 {lab=k13_ff.net11}
N 12480 180 12480 90 {lab=k13_ff.net11}
N 14840 890 14840 800 {lab=k14_ff.net6}
N 14840 800 14880 800 {lab=k14_ff.net6}
N 14880 800 14880 180 {lab=k14_ff.net6}
N 14880 180 14840 180 {lab=k14_ff.net6}
N 14840 180 14840 90 {lab=k14_ff.net6}
N 15800 800 15800 890 {lab=k14_ff.net11}
N 15800 800 15840 800 {lab=k14_ff.net11}
N 15840 800 15840 180 {lab=k14_ff.net11}
N 15840 180 15800 180 {lab=k14_ff.net11}
N 15800 180 15800 90 {lab=k14_ff.net11}
N 17440 890 17440 830 {lab=k15_ff.net6}
N 17440 830 17480 830 {lab=k15_ff.net6}
N 17440 830 17440 800 {lab=k15_ff.net6}
N 17480 830 17480 180 {lab=k15_ff.net6}
N 17480 180 17440 180 {lab=k15_ff.net6}
N 17440 180 17440 90 {lab=k15_ff.net6}
N 18400 800 18440 800 {lab=k15_ff.net11}
N 18400 800 18400 890 {lab=k15_ff.net11}
N 18440 800 18440 180 {lab=k15_ff.net11}
N 18440 180 18400 180 {lab=k15_ff.net11}
N 18400 180 18400 90 {lab=k15_ff.net11}
N 51400 890 51400 800 {lab=k1_ff.net6}
N 51400 800 51440 800 {lab=k1_ff.net6}
N 51440 800 51440 180 {lab=k1_ff.net6}
N 51440 180 51400 180 {lab=k1_ff.net6}
N 51400 180 51400 90 {lab=k1_ff.net6}
N 52360 800 52420 800 {lab=k1_ff.net11}
N 52360 800 52360 890 {lab=k1_ff.net11}
N 52420 800 52420 180 {lab=k1_ff.net11}
N 52420 180 52360 180 {lab=k1_ff.net11}
N 52360 180 52360 90 {lab=k1_ff.net11}
N 22760 890 22760 800 {lab=k2_ff.net6}
N 22760 800 22800 800 {lab=k2_ff.net6}
N 22800 800 22800 180 {lab=k2_ff.net6}
N 22800 180 22760 180 {lab=k2_ff.net6}
N 22760 180 22760 90 {lab=k2_ff.net6}
N 23720 800 23720 830 {lab=k2_ff.net11}
N 23720 830 23720 890 {lab=k2_ff.net11}
N 23720 830 23760 830 {lab=k2_ff.net11}
N 23760 830 23760 180 {lab=k2_ff.net11}
N 23760 180 23720 180 {lab=k2_ff.net11}
N 23720 180 23720 90 {lab=k2_ff.net11}
N 26080 890 26080 800 {lab=k3_ff.net6}
N 26080 800 26120 800 {lab=k3_ff.net6}
N 26120 800 26120 180 {lab=k3_ff.net6}
N 26120 180 26080 180 {lab=k3_ff.net6}
N 26080 180 26080 90 {lab=k3_ff.net6}
N 27040 800 27040 890 {lab=k3_ff.net11}
N 27040 800 27080 800 {lab=k3_ff.net11}
N 27080 800 27080 180 {lab=k3_ff.net11}
N 27080 180 27040 180 {lab=k3_ff.net11}
N 27040 180 27040 90 {lab=k3_ff.net11}
N 29400 890 29400 800 {lab=k4_ff.net6}
N 29400 800 29440 800 {lab=k4_ff.net6}
N 29440 800 29440 180 {lab=k4_ff.net6}
N 29440 180 29400 180 {lab=k4_ff.net6}
N 29400 180 29400 90 {lab=k4_ff.net6}
N 30360 800 30360 890 {lab=k4_ff.net11}
N 30360 800 30400 800 {lab=k4_ff.net11}
N 30400 800 30400 180 {lab=k4_ff.net11}
N 30400 180 30360 180 {lab=k4_ff.net11}
N 30360 180 30360 90 {lab=k4_ff.net11}
N 32720 890 32720 800 {lab=k5_ff.net6}
N 32720 800 32760 800 {lab=k5_ff.net6}
N 32760 800 32760 180 {lab=k5_ff.net6}
N 32760 180 32720 180 {lab=k5_ff.net6}
N 32720 180 32720 90 {lab=k5_ff.net6}
N 33680 800 33720 800 {lab=k5_ff.net11}
N 33680 800 33680 890 {lab=k5_ff.net11}
N 33720 800 33720 180 {lab=k5_ff.net11}
N 33720 180 33680 180 {lab=k5_ff.net11}
N 33680 180 33680 90 {lab=k5_ff.net11}
N 36040 890 36040 800 {lab=k6_ff.net6}
N 36040 800 36080 800 {lab=k6_ff.net6}
N 36080 800 36080 180 {lab=k6_ff.net6}
N 36080 180 36040 180 {lab=k6_ff.net6}
N 36040 180 36040 90 {lab=k6_ff.net6}
N 37000 800 37000 890 {lab=k6_ff.net11}
N 37000 800 37040 800 {lab=k6_ff.net11}
N 37040 800 37040 180 {lab=k6_ff.net11}
N 37040 180 37000 180 {lab=k6_ff.net11}
N 37000 180 37000 90 {lab=k6_ff.net11}
N 39360 890 39360 800 {lab=k7_ff.net6}
N 39360 800 39400 800 {lab=k7_ff.net6}
N 39400 800 39400 180 {lab=k7_ff.net6}
N 39400 180 39360 180 {lab=k7_ff.net6}
N 39360 180 39360 90 {lab=k7_ff.net6}
N 40320 800 40320 890 {lab=k7_ff.net11}
N 40320 800 40360 800 {lab=k7_ff.net11}
N 40360 800 40360 180 {lab=k7_ff.net11}
N 40360 180 40320 180 {lab=k7_ff.net11}
N 40320 180 40320 90 {lab=k7_ff.net11}
N 42680 890 42680 800 {lab=k8_ff.net6}
N 42680 800 42720 800 {lab=k8_ff.net6}
N 42720 800 42720 180 {lab=k8_ff.net6}
N 42720 180 42680 180 {lab=k8_ff.net6}
N 42680 180 42680 90 {lab=k8_ff.net6}
N 43640 800 43640 830 {lab=k8_ff.net11}
N 43640 830 43640 890 {lab=k8_ff.net11}
N 43640 830 43680 830 {lab=k8_ff.net11}
N 43680 830 43680 180 {lab=k8_ff.net11}
N 43680 180 43640 180 {lab=k8_ff.net11}
N 43640 180 43640 90 {lab=k8_ff.net11}
N 47320 890 47320 800 {lab=k9_ff.net6}
N 47320 800 47360 800 {lab=k9_ff.net6}
N 47360 800 47360 180 {lab=k9_ff.net6}
N 47360 180 47320 180 {lab=k9_ff.net6}
N 47320 180 47320 90 {lab=k9_ff.net6}
N 48280 800 48280 890 {lab=k9_ff.net11}
N 48280 800 48320 800 {lab=k9_ff.net11}
N 48320 800 48320 180 {lab=k9_ff.net11}
N 48320 180 48280 180 {lab=k9_ff.net11}
N 48280 180 48280 90 {lab=k9_ff.net11}
N 52720 890 52720 800 {lab=k0_ff.net6}
N 52720 800 52760 800 {lab=k0_ff.net6}
N 52760 800 52760 180 {lab=k0_ff.net6}
N 52760 180 52720 180 {lab=k0_ff.net6}
N 52720 180 52720 90 {lab=k0_ff.net6}
N 53680 800 53680 890 {lab=k0_ff.net11}
N 53680 800 53690 800 {lab=k0_ff.net11}
N 53690 800 53690 780 {lab=k0_ff.net11}
N 53690 780 53730 780 {lab=k0_ff.net11}
N 53730 780 53730 760 {lab=k0_ff.net11}
N 53730 760 53700 760 {lab=k0_ff.net11}
N 53700 760 53700 640 {lab=k0_ff.net11}
N 53700 640 53720 640 {lab=k0_ff.net11}
N 53720 640 53720 180 {lab=k0_ff.net11}
N 53720 180 53680 180 {lab=k0_ff.net11}
N 53680 180 53680 90 {lab=k0_ff.net11}
N 46400 180 46400 100 {lab=k10_ff.net9}
N 46400 100 46200 100 {lab=k10_ff.net9}
N 46400 100 46400 90 {lab=k10_ff.net9}
N 46200 100 46200 90 {lab=k10_ff.net9}
N 5280 180 5280 100 {lab=k11_ff.net9}
N 5280 100 5280 90 {lab=k11_ff.net9}
N 5280 100 5080 100 {lab=k11_ff.net9}
N 5080 100 5080 90 {lab=k11_ff.net9}
N 8600 180 8600 100 {lab=k12_ff.net9}
N 8600 100 8400 100 {lab=k12_ff.net9}
N 8600 100 8600 90 {lab=k12_ff.net9}
N 8400 100 8400 90 {lab=k12_ff.net9}
N 11920 180 11920 100 {lab=k13_ff.net9}
N 11920 100 11720 100 {lab=k13_ff.net9}
N 11920 100 11920 90 {lab=k13_ff.net9}
N 11720 100 11720 90 {lab=k13_ff.net9}
N 15240 180 15240 100 {lab=k14_ff.net9}
N 15240 100 15040 100 {lab=k14_ff.net9}
N 15240 100 15240 90 {lab=k14_ff.net9}
N 15040 100 15040 90 {lab=k14_ff.net9}
N 17840 180 17840 100 {lab=k15_ff.net9}
N 17840 100 17640 100 {lab=k15_ff.net9}
N 17840 100 17840 90 {lab=k15_ff.net9}
N 17640 100 17640 90 {lab=k15_ff.net9}
N 51800 180 51800 100 {lab=k1_ff.net9}
N 51800 100 51800 90 {lab=k1_ff.net9}
N 51800 100 51600 100 {lab=k1_ff.net9}
N 51600 100 51600 90 {lab=k1_ff.net9}
N 23160 180 23160 100 {lab=k2_ff.net9}
N 23160 100 23160 90 {lab=k2_ff.net9}
N 23160 100 22960 100 {lab=k2_ff.net9}
N 22960 100 22960 90 {lab=k2_ff.net9}
N 26480 180 26480 100 {lab=k3_ff.net9}
N 26480 100 26280 100 {lab=k3_ff.net9}
N 26480 100 26480 90 {lab=k3_ff.net9}
N 26280 100 26280 90 {lab=k3_ff.net9}
N 29800 180 29800 100 {lab=k4_ff.net9}
N 29800 100 29600 100 {lab=k4_ff.net9}
N 29800 100 29800 90 {lab=k4_ff.net9}
N 29600 100 29600 90 {lab=k4_ff.net9}
N 33120 180 33120 100 {lab=k5_ff.net9}
N 33120 100 32920 100 {lab=k5_ff.net9}
N 33120 100 33120 90 {lab=k5_ff.net9}
N 32920 100 32920 90 {lab=k5_ff.net9}
N 36440 180 36440 100 {lab=k6_ff.net9}
N 36440 100 36240 100 {lab=k6_ff.net9}
N 36440 100 36440 90 {lab=k6_ff.net9}
N 36240 100 36240 90 {lab=k6_ff.net9}
N 39760 180 39760 100 {lab=k7_ff.net9}
N 39760 100 39760 90 {lab=k7_ff.net9}
N 39760 100 39560 100 {lab=k7_ff.net9}
N 39560 100 39560 90 {lab=k7_ff.net9}
N 43080 180 43080 100 {lab=k8_ff.net9}
N 43080 100 42880 100 {lab=k8_ff.net9}
N 43080 100 43080 90 {lab=k8_ff.net9}
N 42880 100 42880 90 {lab=k8_ff.net9}
N 47720 180 47720 100 {lab=k9_ff.net9}
N 47720 100 47720 90 {lab=k9_ff.net9}
N 47720 100 47520 100 {lab=k9_ff.net9}
N 47520 100 47520 90 {lab=k9_ff.net9}
N 53120 180 53120 100 {lab=k0_ff.net9}
N 53120 100 53120 90 {lab=k0_ff.net9}
N 53120 100 52920 100 {lab=k0_ff.net9}
N 52920 100 52920 90 {lab=k0_ff.net9}
N 50120 90 50120 170 {lab=k0_xor.net_1}
N 50120 170 50120 180 {lab=k0_xor.net_1}
N 50120 170 50320 170 {lab=k0_xor.net_1}
N 50320 170 50320 180 {lab=k0_xor.net_1}
N 120 920 -60 920 {lab=tick_n}
N -60 920 -60 590 {lab=tick_n}
N -60 590 -40 590 {lab=tick_n}
N -40 590 -40 60 {lab=tick_n}
N -40 60 120 60 {lab=tick_n}
N 50120 740 50300 740 {lab=k0_xor.net_0}
N 50300 740 50300 820 {lab=k0_xor.net_0}
N 50300 820 50320 820 {lab=k0_xor.net_0}
N 50320 820 50320 890 {lab=k0_xor.net_0}
N 46200 650 46200 740 {lab=k10_ff.net15}
N 46200 800 46200 890 {lab=k10_ff.net12}
N 880 890 880 800 {lab=k10_ff.net0}
N 5080 650 5080 740 {lab=k11_ff.net15}
N 5080 800 5080 890 {lab=k11_ff.net12}
N 2880 890 2880 800 {lab=k11_ff.net0}
N 8400 650 8400 740 {lab=k12_ff.net15}
N 8400 800 8400 890 {lab=k12_ff.net12}
N 6200 890 6200 800 {lab=k12_ff.net0}
N 11720 650 11720 740 {lab=k13_ff.net15}
N 11720 800 11720 890 {lab=k13_ff.net12}
N 9520 890 9520 800 {lab=k13_ff.net0}
N 15040 650 15040 740 {lab=k14_ff.net15}
N 15040 800 15040 890 {lab=k14_ff.net12}
N 12840 890 12840 800 {lab=k14_ff.net0}
N 17640 650 17640 740 {lab=k15_ff.net15}
N 17640 800 17640 890 {lab=k15_ff.net12}
N 16160 890 16160 800 {lab=k15_ff.net0}
N 51600 650 51600 740 {lab=k1_ff.net15}
N 51600 800 51600 890 {lab=k1_ff.net12}
N 18760 890 18760 800 {lab=k1_ff.net0}
N 22960 650 22960 740 {lab=k2_ff.net15}
N 22960 800 22960 890 {lab=k2_ff.net12}
N 20760 890 20760 800 {lab=k2_ff.net0}
N 26280 650 26280 740 {lab=k3_ff.net15}
N 26280 800 26280 890 {lab=k3_ff.net12}
N 24080 890 24080 800 {lab=k3_ff.net0}
N 29600 650 29600 740 {lab=k4_ff.net15}
N 29600 800 29600 890 {lab=k4_ff.net12}
N 27400 890 27400 800 {lab=k4_ff.net0}
N 32920 650 32920 740 {lab=k5_ff.net15}
N 32920 800 32920 890 {lab=k5_ff.net12}
N 30720 890 30720 800 {lab=k5_ff.net0}
N 36240 650 36240 740 {lab=k6_ff.net15}
N 36240 800 36240 890 {lab=k6_ff.net12}
N 34040 890 34040 800 {lab=k6_ff.net0}
N 39560 650 39560 740 {lab=k7_ff.net15}
N 39560 800 39560 890 {lab=k7_ff.net12}
N 37360 890 37360 800 {lab=k7_ff.net0}
N 42880 650 42880 740 {lab=k8_ff.net15}
N 42880 800 42880 890 {lab=k8_ff.net12}
N 40680 890 40680 800 {lab=k8_ff.net0}
N 47520 650 47520 740 {lab=k9_ff.net15}
N 47520 800 47520 890 {lab=k9_ff.net12}
N 44000 890 44000 800 {lab=k9_ff.net0}
N 52920 650 52920 740 {lab=k0_ff.net15}
N 52920 800 52920 890 {lab=k0_ff.net12}
N 48640 890 48640 800 {lab=k0_ff.net0}
N 49560 180 49560 90 {lab=k0_xor.net_2}
C {devices/ipin.sym} -60 510 0 0 {name=p813 lab=event_bit}
C {devices/ipin.sym} -60 550 0 0 {name=p814 lab=run}
C {devices/ipin.sym} -60 590 0 0 {name=p815 lab=tick_n}
C {devices/opin.sym} 54060 250 0 0 {name=p816 lab=k_0}
C {devices/opin.sym} 54060 290 0 0 {name=p817 lab=k_10}
C {devices/opin.sym} 54060 330 0 0 {name=p818 lab=k_11}
C {devices/opin.sym} 54060 370 0 0 {name=p819 lab=k_12}
C {devices/opin.sym} 54060 410 0 0 {name=p820 lab=k_13}
C {devices/opin.sym} 54060 450 0 0 {name=p821 lab=k_14}
C {devices/opin.sym} 54060 490 0 0 {name=p822 lab=k_15}
C {devices/opin.sym} 54060 530 0 0 {name=p823 lab=k_1}
C {devices/opin.sym} 54060 570 0 0 {name=p824 lab=k_2}
C {devices/opin.sym} 54060 610 0 0 {name=p825 lab=k_3}
C {devices/opin.sym} 54060 650 0 0 {name=p826 lab=k_4}
C {devices/opin.sym} 54060 690 0 0 {name=p827 lab=k_5}
C {devices/opin.sym} 54060 730 0 0 {name=p828 lab=k_6}
C {devices/opin.sym} 54060 770 0 0 {name=p829 lab=k_7}
C {devices/opin.sym} 54060 810 0 0 {name=p830 lab=k_8}
C {devices/opin.sym} 54060 850 0 0 {name=p831 lab=k_9}
