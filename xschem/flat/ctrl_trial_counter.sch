v {xschem version=3.4.4 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {ctrl_trial_counter: controller block "trial_counter" at transistor level (34 cells)} 0 -230 0 0 0.45 0.45 {}
T {Trial counter n: each bit clocked by the bit below, except n_1 by n_n_0; n_16 rises on count 65,535} 0 -190 0 0 0.26 0.26 {}
T {From src/gf180/compact_control.v; every cell opened up. Stage labels are the cell instance names.} 0 -162 0 0 0.26 0.26 {}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 140 920 0 0 {name=Mn0_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 500 920 0 0 {name=Mn0_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2860 920 0 0 {name=Mn0_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2860 770 0 0 {name=Mn0_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3060 620 0 0 {name=Mn0_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3060 770 0 0 {name=Mn0_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3060 920 0 0 {name=Mn0_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3620 920 0 0 {name=Mn0_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3620 770 0 0 {name=Mn0_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3820 770 0 0 {name=Mn0_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 3820 920 0 0 {name=Mn0_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 860 920 0 0 {name=Mn0_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 860 770 0 0 {name=Mn0_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1420 920 0 0 {name=Mn0_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 140 60 0 0 {name=Mn0_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 500 60 0 0 {name=Mn0_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2860 60 0 0 {name=Mn0_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2860 210 0 0 {name=Mn0_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3260 210 0 0 {name=Mn0_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3060 60 0 0 {name=Mn0_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3260 60 0 0 {name=Mn0_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3620 60 0 0 {name=Mn0_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3620 210 0 0 {name=Mn0_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3820 210 0 0 {name=Mn0_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 3820 60 0 0 {name=Mn0_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 860 60 0 0 {name=Mn0_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1060 60 0 0 {name=Mn0_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1420 60 0 0 {name=Mn0_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 1780 920 0 0 {name=Mn0_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 1780 60 0 0 {name=Mn0_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52860 920 0 0 {name=Mn10_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53220 920 0 0 {name=Mn10_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53940 920 0 0 {name=Mn10_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53940 770 0 0 {name=Mn10_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54140 620 0 0 {name=Mn10_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54140 770 0 0 {name=Mn10_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54140 920 0 0 {name=Mn10_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54700 920 0 0 {name=Mn10_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54700 770 0 0 {name=Mn10_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54900 770 0 0 {name=Mn10_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 54900 920 0 0 {name=Mn10_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4180 920 0 0 {name=Mn10_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4180 770 0 0 {name=Mn10_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 4740 920 0 0 {name=Mn10_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52860 60 0 0 {name=Mn10_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53220 60 0 0 {name=Mn10_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53940 60 0 0 {name=Mn10_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53940 210 0 0 {name=Mn10_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54340 210 0 0 {name=Mn10_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54140 60 0 0 {name=Mn10_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54340 60 0 0 {name=Mn10_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54700 60 0 0 {name=Mn10_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54700 210 0 0 {name=Mn10_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54900 210 0 0 {name=Mn10_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 54900 60 0 0 {name=Mn10_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4180 60 0 0 {name=Mn10_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4380 60 0 0 {name=Mn10_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 4740 60 0 0 {name=Mn10_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5100 920 0 0 {name=Mn10_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5100 60 0 0 {name=Mn10_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5460 920 0 0 {name=Mn11_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 5820 920 0 0 {name=Mn11_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8180 920 0 0 {name=Mn11_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8180 770 0 0 {name=Mn11_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8380 620 0 0 {name=Mn11_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8380 770 0 0 {name=Mn11_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8380 920 0 0 {name=Mn11_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8940 920 0 0 {name=Mn11_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 8940 770 0 0 {name=Mn11_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9140 770 0 0 {name=Mn11_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9140 920 0 0 {name=Mn11_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6180 920 0 0 {name=Mn11_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6180 770 0 0 {name=Mn11_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 6740 920 0 0 {name=Mn11_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5460 60 0 0 {name=Mn11_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 5820 60 0 0 {name=Mn11_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8180 60 0 0 {name=Mn11_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8180 210 0 0 {name=Mn11_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8580 210 0 0 {name=Mn11_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8380 60 0 0 {name=Mn11_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8580 60 0 0 {name=Mn11_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8940 60 0 0 {name=Mn11_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 8940 210 0 0 {name=Mn11_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9140 210 0 0 {name=Mn11_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9140 60 0 0 {name=Mn11_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6180 60 0 0 {name=Mn11_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6380 60 0 0 {name=Mn11_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 6740 60 0 0 {name=Mn11_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7100 920 0 0 {name=Mn11_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7100 60 0 0 {name=Mn11_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7460 920 0 0 {name=Mn12_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 7820 920 0 0 {name=Mn12_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11500 920 0 0 {name=Mn12_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11500 770 0 0 {name=Mn12_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11700 620 0 0 {name=Mn12_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11700 770 0 0 {name=Mn12_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11700 920 0 0 {name=Mn12_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12260 920 0 0 {name=Mn12_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12260 770 0 0 {name=Mn12_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12460 770 0 0 {name=Mn12_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12460 920 0 0 {name=Mn12_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9500 920 0 0 {name=Mn12_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 9500 770 0 0 {name=Mn12_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10060 920 0 0 {name=Mn12_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7460 60 0 0 {name=Mn12_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 7820 60 0 0 {name=Mn12_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11500 60 0 0 {name=Mn12_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11500 210 0 0 {name=Mn12_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11900 210 0 0 {name=Mn12_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11700 60 0 0 {name=Mn12_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11900 60 0 0 {name=Mn12_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12260 60 0 0 {name=Mn12_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12260 210 0 0 {name=Mn12_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12460 210 0 0 {name=Mn12_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12460 60 0 0 {name=Mn12_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9500 60 0 0 {name=Mn12_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 9700 60 0 0 {name=Mn12_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10060 60 0 0 {name=Mn12_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10420 920 0 0 {name=Mn12_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10420 60 0 0 {name=Mn12_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 10780 920 0 0 {name=Mn13_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 11140 920 0 0 {name=Mn13_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14820 920 0 0 {name=Mn13_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14820 770 0 0 {name=Mn13_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15020 620 0 0 {name=Mn13_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15020 770 0 0 {name=Mn13_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15020 920 0 0 {name=Mn13_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15580 920 0 0 {name=Mn13_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15580 770 0 0 {name=Mn13_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15780 770 0 0 {name=Mn13_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 15780 920 0 0 {name=Mn13_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12820 920 0 0 {name=Mn13_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 12820 770 0 0 {name=Mn13_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13380 920 0 0 {name=Mn13_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 10780 60 0 0 {name=Mn13_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 11140 60 0 0 {name=Mn13_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14820 60 0 0 {name=Mn13_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14820 210 0 0 {name=Mn13_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15220 210 0 0 {name=Mn13_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15020 60 0 0 {name=Mn13_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15220 60 0 0 {name=Mn13_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15580 60 0 0 {name=Mn13_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15580 210 0 0 {name=Mn13_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15780 210 0 0 {name=Mn13_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 15780 60 0 0 {name=Mn13_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 12820 60 0 0 {name=Mn13_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13020 60 0 0 {name=Mn13_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13380 60 0 0 {name=Mn13_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 13740 920 0 0 {name=Mn13_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 13740 60 0 0 {name=Mn13_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14100 920 0 0 {name=Mn14_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 14460 920 0 0 {name=Mn14_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18140 920 0 0 {name=Mn14_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18140 770 0 0 {name=Mn14_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18340 620 0 0 {name=Mn14_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18340 770 0 0 {name=Mn14_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18340 920 0 0 {name=Mn14_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18900 920 0 0 {name=Mn14_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 18900 770 0 0 {name=Mn14_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19100 770 0 0 {name=Mn14_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19100 920 0 0 {name=Mn14_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16140 920 0 0 {name=Mn14_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16140 770 0 0 {name=Mn14_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 16700 920 0 0 {name=Mn14_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14100 60 0 0 {name=Mn14_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 14460 60 0 0 {name=Mn14_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18140 60 0 0 {name=Mn14_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18140 210 0 0 {name=Mn14_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18540 210 0 0 {name=Mn14_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18340 60 0 0 {name=Mn14_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18540 60 0 0 {name=Mn14_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18900 60 0 0 {name=Mn14_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 18900 210 0 0 {name=Mn14_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19100 210 0 0 {name=Mn14_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19100 60 0 0 {name=Mn14_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16140 60 0 0 {name=Mn14_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16340 60 0 0 {name=Mn14_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 16700 60 0 0 {name=Mn14_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17060 920 0 0 {name=Mn14_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17060 60 0 0 {name=Mn14_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17420 920 0 0 {name=Mn15_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 17780 920 0 0 {name=Mn15_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21460 920 0 0 {name=Mn15_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21460 770 0 0 {name=Mn15_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21660 620 0 0 {name=Mn15_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21660 770 0 0 {name=Mn15_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21660 920 0 0 {name=Mn15_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22220 920 0 0 {name=Mn15_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22220 770 0 0 {name=Mn15_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22420 770 0 0 {name=Mn15_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22420 920 0 0 {name=Mn15_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19460 920 0 0 {name=Mn15_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 19460 770 0 0 {name=Mn15_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20020 920 0 0 {name=Mn15_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17420 60 0 0 {name=Mn15_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 17780 60 0 0 {name=Mn15_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21460 60 0 0 {name=Mn15_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21460 210 0 0 {name=Mn15_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21860 210 0 0 {name=Mn15_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21660 60 0 0 {name=Mn15_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21860 60 0 0 {name=Mn15_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22220 60 0 0 {name=Mn15_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22220 210 0 0 {name=Mn15_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22420 210 0 0 {name=Mn15_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22420 60 0 0 {name=Mn15_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19460 60 0 0 {name=Mn15_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 19660 60 0 0 {name=Mn15_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20020 60 0 0 {name=Mn15_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20380 920 0 0 {name=Mn15_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20380 60 0 0 {name=Mn15_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 20740 920 0 0 {name=Mn16_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 21100 920 0 0 {name=Mn16_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24060 920 0 0 {name=Mn16_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24060 770 0 0 {name=Mn16_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24260 620 0 0 {name=Mn16_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24260 770 0 0 {name=Mn16_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24260 920 0 0 {name=Mn16_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24820 920 0 0 {name=Mn16_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 24820 770 0 0 {name=Mn16_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25020 770 0 0 {name=Mn16_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25020 920 0 0 {name=Mn16_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22780 920 0 0 {name=Mn16_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 22780 770 0 0 {name=Mn16_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23340 920 0 0 {name=Mn16_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 20740 60 0 0 {name=Mn16_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 21100 60 0 0 {name=Mn16_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24060 60 0 0 {name=Mn16_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24060 210 0 0 {name=Mn16_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24460 210 0 0 {name=Mn16_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24260 60 0 0 {name=Mn16_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24460 60 0 0 {name=Mn16_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24820 60 0 0 {name=Mn16_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 24820 210 0 0 {name=Mn16_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25020 210 0 0 {name=Mn16_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25020 60 0 0 {name=Mn16_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22780 60 0 0 {name=Mn16_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 22980 60 0 0 {name=Mn16_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23340 60 0 0 {name=Mn16_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 23700 920 0 0 {name=Mn16_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 23700 60 0 0 {name=Mn16_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2140 920 0 0 {name=Mn1_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 2500 920 0 0 {name=Mn1_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27380 920 0 0 {name=Mn1_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27380 770 0 0 {name=Mn1_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27580 620 0 0 {name=Mn1_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27580 770 0 0 {name=Mn1_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27580 920 0 0 {name=Mn1_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28140 920 0 0 {name=Mn1_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28140 770 0 0 {name=Mn1_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28340 770 0 0 {name=Mn1_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28340 920 0 0 {name=Mn1_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25380 920 0 0 {name=Mn1_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25380 770 0 0 {name=Mn1_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 25940 920 0 0 {name=Mn1_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2140 60 0 0 {name=Mn1_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 2500 60 0 0 {name=Mn1_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27380 60 0 0 {name=Mn1_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27380 210 0 0 {name=Mn1_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27780 210 0 0 {name=Mn1_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27580 60 0 0 {name=Mn1_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27780 60 0 0 {name=Mn1_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28140 60 0 0 {name=Mn1_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28140 210 0 0 {name=Mn1_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28340 210 0 0 {name=Mn1_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28340 60 0 0 {name=Mn1_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25380 60 0 0 {name=Mn1_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25580 60 0 0 {name=Mn1_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 25940 60 0 0 {name=Mn1_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26300 920 0 0 {name=Mn1_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26300 60 0 0 {name=Mn1_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 26660 920 0 0 {name=Mn2_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 27020 920 0 0 {name=Mn2_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30700 920 0 0 {name=Mn2_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30700 770 0 0 {name=Mn2_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30900 620 0 0 {name=Mn2_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30900 770 0 0 {name=Mn2_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30900 920 0 0 {name=Mn2_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31460 920 0 0 {name=Mn2_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31460 770 0 0 {name=Mn2_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31660 770 0 0 {name=Mn2_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 31660 920 0 0 {name=Mn2_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28700 920 0 0 {name=Mn2_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 28700 770 0 0 {name=Mn2_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29260 920 0 0 {name=Mn2_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 26660 60 0 0 {name=Mn2_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 27020 60 0 0 {name=Mn2_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30700 60 0 0 {name=Mn2_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30700 210 0 0 {name=Mn2_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31100 210 0 0 {name=Mn2_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30900 60 0 0 {name=Mn2_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31100 60 0 0 {name=Mn2_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31460 60 0 0 {name=Mn2_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31460 210 0 0 {name=Mn2_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31660 210 0 0 {name=Mn2_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 31660 60 0 0 {name=Mn2_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28700 60 0 0 {name=Mn2_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 28900 60 0 0 {name=Mn2_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29260 60 0 0 {name=Mn2_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29620 920 0 0 {name=Mn2_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29620 60 0 0 {name=Mn2_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 29980 920 0 0 {name=Mn3_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 30340 920 0 0 {name=Mn3_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34020 920 0 0 {name=Mn3_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34020 770 0 0 {name=Mn3_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34220 620 0 0 {name=Mn3_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34220 770 0 0 {name=Mn3_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34220 920 0 0 {name=Mn3_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34780 920 0 0 {name=Mn3_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34780 770 0 0 {name=Mn3_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34980 770 0 0 {name=Mn3_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 34980 920 0 0 {name=Mn3_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32020 920 0 0 {name=Mn3_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32020 770 0 0 {name=Mn3_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32580 920 0 0 {name=Mn3_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 29980 60 0 0 {name=Mn3_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 30340 60 0 0 {name=Mn3_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34020 60 0 0 {name=Mn3_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34020 210 0 0 {name=Mn3_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34420 210 0 0 {name=Mn3_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34220 60 0 0 {name=Mn3_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34420 60 0 0 {name=Mn3_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34780 60 0 0 {name=Mn3_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34780 210 0 0 {name=Mn3_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34980 210 0 0 {name=Mn3_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 34980 60 0 0 {name=Mn3_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32020 60 0 0 {name=Mn3_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32220 60 0 0 {name=Mn3_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32580 60 0 0 {name=Mn3_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 32940 920 0 0 {name=Mn3_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 32940 60 0 0 {name=Mn3_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33300 920 0 0 {name=Mn4_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 33660 920 0 0 {name=Mn4_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37340 920 0 0 {name=Mn4_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37340 770 0 0 {name=Mn4_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37540 620 0 0 {name=Mn4_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37540 770 0 0 {name=Mn4_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 37540 920 0 0 {name=Mn4_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38100 920 0 0 {name=Mn4_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38100 770 0 0 {name=Mn4_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38300 770 0 0 {name=Mn4_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38300 920 0 0 {name=Mn4_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35340 920 0 0 {name=Mn4_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35340 770 0 0 {name=Mn4_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 35900 920 0 0 {name=Mn4_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33300 60 0 0 {name=Mn4_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 33660 60 0 0 {name=Mn4_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37340 60 0 0 {name=Mn4_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37340 210 0 0 {name=Mn4_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37740 210 0 0 {name=Mn4_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37540 60 0 0 {name=Mn4_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 37740 60 0 0 {name=Mn4_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38100 60 0 0 {name=Mn4_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38100 210 0 0 {name=Mn4_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38300 210 0 0 {name=Mn4_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38300 60 0 0 {name=Mn4_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35340 60 0 0 {name=Mn4_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35540 60 0 0 {name=Mn4_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 35900 60 0 0 {name=Mn4_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36260 920 0 0 {name=Mn4_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36260 60 0 0 {name=Mn4_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36620 920 0 0 {name=Mn5_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 36980 920 0 0 {name=Mn5_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40660 920 0 0 {name=Mn5_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40660 770 0 0 {name=Mn5_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40860 620 0 0 {name=Mn5_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40860 770 0 0 {name=Mn5_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40860 920 0 0 {name=Mn5_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41420 920 0 0 {name=Mn5_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41420 770 0 0 {name=Mn5_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41620 770 0 0 {name=Mn5_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41620 920 0 0 {name=Mn5_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38660 920 0 0 {name=Mn5_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 38660 770 0 0 {name=Mn5_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39220 920 0 0 {name=Mn5_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36620 60 0 0 {name=Mn5_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 36980 60 0 0 {name=Mn5_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40660 60 0 0 {name=Mn5_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40660 210 0 0 {name=Mn5_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41060 210 0 0 {name=Mn5_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40860 60 0 0 {name=Mn5_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41060 60 0 0 {name=Mn5_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41420 60 0 0 {name=Mn5_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41420 210 0 0 {name=Mn5_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41620 210 0 0 {name=Mn5_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41620 60 0 0 {name=Mn5_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38660 60 0 0 {name=Mn5_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 38860 60 0 0 {name=Mn5_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39220 60 0 0 {name=Mn5_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39580 920 0 0 {name=Mn5_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39580 60 0 0 {name=Mn5_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 39940 920 0 0 {name=Mn6_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 40300 920 0 0 {name=Mn6_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43980 920 0 0 {name=Mn6_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43980 770 0 0 {name=Mn6_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44180 620 0 0 {name=Mn6_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44180 770 0 0 {name=Mn6_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44180 920 0 0 {name=Mn6_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44740 920 0 0 {name=Mn6_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44740 770 0 0 {name=Mn6_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44940 770 0 0 {name=Mn6_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 44940 920 0 0 {name=Mn6_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41980 920 0 0 {name=Mn6_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 41980 770 0 0 {name=Mn6_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42540 920 0 0 {name=Mn6_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 39940 60 0 0 {name=Mn6_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 40300 60 0 0 {name=Mn6_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43980 60 0 0 {name=Mn6_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43980 210 0 0 {name=Mn6_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44380 210 0 0 {name=Mn6_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44180 60 0 0 {name=Mn6_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44380 60 0 0 {name=Mn6_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44740 60 0 0 {name=Mn6_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44740 210 0 0 {name=Mn6_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44940 210 0 0 {name=Mn6_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 44940 60 0 0 {name=Mn6_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 41980 60 0 0 {name=Mn6_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42180 60 0 0 {name=Mn6_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42540 60 0 0 {name=Mn6_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 42900 920 0 0 {name=Mn6_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 42900 60 0 0 {name=Mn6_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43260 920 0 0 {name=Mn7_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 43620 920 0 0 {name=Mn7_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47300 920 0 0 {name=Mn7_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47300 770 0 0 {name=Mn7_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47500 620 0 0 {name=Mn7_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47500 770 0 0 {name=Mn7_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 47500 920 0 0 {name=Mn7_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48060 920 0 0 {name=Mn7_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48060 770 0 0 {name=Mn7_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48260 770 0 0 {name=Mn7_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48260 920 0 0 {name=Mn7_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45300 920 0 0 {name=Mn7_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45300 770 0 0 {name=Mn7_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 45860 920 0 0 {name=Mn7_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43260 60 0 0 {name=Mn7_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 43620 60 0 0 {name=Mn7_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47300 60 0 0 {name=Mn7_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47300 210 0 0 {name=Mn7_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47700 210 0 0 {name=Mn7_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47500 60 0 0 {name=Mn7_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 47700 60 0 0 {name=Mn7_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48060 60 0 0 {name=Mn7_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48060 210 0 0 {name=Mn7_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48260 210 0 0 {name=Mn7_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48260 60 0 0 {name=Mn7_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45300 60 0 0 {name=Mn7_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45500 60 0 0 {name=Mn7_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 45860 60 0 0 {name=Mn7_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46220 920 0 0 {name=Mn7_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46220 60 0 0 {name=Mn7_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46580 920 0 0 {name=Mn8_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 46940 920 0 0 {name=Mn8_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50620 920 0 0 {name=Mn8_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50620 770 0 0 {name=Mn8_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50820 620 0 0 {name=Mn8_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50820 770 0 0 {name=Mn8_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50820 920 0 0 {name=Mn8_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51380 920 0 0 {name=Mn8_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51380 770 0 0 {name=Mn8_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51580 770 0 0 {name=Mn8_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51580 920 0 0 {name=Mn8_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48620 920 0 0 {name=Mn8_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 48620 770 0 0 {name=Mn8_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49180 920 0 0 {name=Mn8_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46580 60 0 0 {name=Mn8_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 46940 60 0 0 {name=Mn8_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50620 60 0 0 {name=Mn8_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50620 210 0 0 {name=Mn8_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51020 210 0 0 {name=Mn8_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50820 60 0 0 {name=Mn8_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51020 60 0 0 {name=Mn8_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51380 60 0 0 {name=Mn8_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51380 210 0 0 {name=Mn8_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51580 210 0 0 {name=Mn8_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51580 60 0 0 {name=Mn8_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48620 60 0 0 {name=Mn8_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 48820 60 0 0 {name=Mn8_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49180 60 0 0 {name=Mn8_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49540 920 0 0 {name=Mn8_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49540 60 0 0 {name=Mn8_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 49900 920 0 0 {name=Mn9_ff_tn13 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 50260 920 0 0 {name=Mn9_ff_tn10 L=0.6u W=0.405u nf=1 m=1 ad=2.025e-13 as=2.025e-13 pd=1.81e-06 ps=1.81e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55260 920 0 0 {name=Mn9_ff_tn11 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55260 770 0 0 {name=Mn9_ff_tn15 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55460 620 0 0 {name=Mn9_ff_tn14 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55460 770 0 0 {name=Mn9_ff_tn8 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 55460 920 0 0 {name=Mn9_ff_tn9 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56020 920 0 0 {name=Mn9_ff_tn18 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56020 770 0 0 {name=Mn9_ff_tn0 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56220 770 0 0 {name=Mn9_ff_tn1 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 56220 920 0 0 {name=Mn9_ff_tn12 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51940 920 0 0 {name=Mn9_ff_tn5 L=0.6u W=0.39u nf=1 m=1 ad=1.95e-13 as=1.95e-13 pd=1.78e-06 ps=1.78e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 51940 770 0 0 {name=Mn9_ff_tn4 L=0.6u W=0.4u nf=1 m=1 ad=2e-13 as=2e-13 pd=1.8e-06 ps=1.8e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 52500 920 0 0 {name=Mn9_ff_tn3 L=0.6u W=0.795u nf=1 m=1 ad=3.975e-13 as=3.975e-13 pd=2.59e-06 ps=2.59e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 49900 60 0 0 {name=Mn9_ff_tp11 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 50260 60 0 0 {name=Mn9_ff_tp8 L=0.5u W=0.865u nf=1 m=1 ad=4.325e-13 as=4.325e-13 pd=2.73e-06 ps=2.73e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55260 60 0 0 {name=Mn9_ff_tp9 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55260 210 0 0 {name=Mn9_ff_tp15 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55660 210 0 0 {name=Mn9_ff_tp7 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55460 60 0 0 {name=Mn9_ff_tp6 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 55660 60 0 0 {name=Mn9_ff_tp12 L=0.5u W=0.76u nf=1 m=1 ad=3.8e-13 as=3.8e-13 pd=2.52e-06 ps=2.52e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56020 60 0 0 {name=Mn9_ff_tp18 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56020 210 0 0 {name=Mn9_ff_tp2 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56220 210 0 0 {name=Mn9_ff_tp3 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 56220 60 0 0 {name=Mn9_ff_tp10 L=0.5u W=0.505u nf=1 m=1 ad=2.525e-13 as=2.525e-13 pd=2.01e-06 ps=2.01e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 51940 60 0 0 {name=Mn9_ff_tp5 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52140 60 0 0 {name=Mn9_ff_tp4 L=0.5u W=0.94u nf=1 m=1 ad=4.7e-13 as=4.7e-13 pd=2.88e-06 ps=2.88e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 52500 60 0 0 {name=Mn9_ff_tp1 L=0.5u W=1.175u nf=1 m=1 ad=5.875e-13 as=5.875e-13 pd=3.35e-06 ps=3.35e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/nfet_06v0.sym} 53580 920 0 0 {name=Mn9_inv_i_0 L=0.6u W=0.82u nf=1 m=1 ad=4.1e-13 as=4.1e-13 pd=2.64e-06 ps=2.64e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=nfet_05v0 spiceprefix=X}
C {/usr/local/share/pdk/gf180mcuD/libs.tech/xschem/symbols/pfet_06v0.sym} 53580 60 0 0 {name=Mn9_inv_i_1 L=0.5u W=1.22u nf=1 m=1 ad=6.1e-13 as=6.1e-13 pd=3.44e-06 ps=3.44e-06 nrd=0 nrs=0 sa=0 sb=0 sd=0 model=pfet_05v0 spiceprefix=X}
T {n0_ff} 110 -35 0 0 0.3 0.3 {}
T {n0_inv} 1750 -35 0 0 0.3 0.3 {}
T {n10_ff} 4150 -35 0 0 0.3 0.3 {}
T {n10_inv} 5070 -35 0 0 0.3 0.3 {}
T {n11_ff} 5430 -35 0 0 0.3 0.3 {}
T {n11_inv} 7070 -35 0 0 0.3 0.3 {}
T {n12_ff} 7430 -35 0 0 0.3 0.3 {}
T {n12_inv} 10390 -35 0 0 0.3 0.3 {}
T {n13_ff} 10750 -35 0 0 0.3 0.3 {}
T {n13_inv} 13710 -35 0 0 0.3 0.3 {}
T {n14_ff} 14070 -35 0 0 0.3 0.3 {}
T {n14_inv} 17030 -35 0 0 0.3 0.3 {}
T {n15_ff} 17390 -35 0 0 0.3 0.3 {}
T {n15_inv} 20350 -35 0 0 0.3 0.3 {}
T {n16_ff} 20710 -35 0 0 0.3 0.3 {}
T {n16_inv} 23670 -35 0 0 0.3 0.3 {}
T {n1_ff} 2110 -35 0 0 0.3 0.3 {}
T {n1_inv} 26270 -35 0 0 0.3 0.3 {}
T {n2_ff} 26630 -35 0 0 0.3 0.3 {}
T {n2_inv} 29590 -35 0 0 0.3 0.3 {}
T {n3_ff} 29950 -35 0 0 0.3 0.3 {}
T {n3_inv} 32910 -35 0 0 0.3 0.3 {}
T {n4_ff} 33270 -35 0 0 0.3 0.3 {}
T {n4_inv} 36230 -35 0 0 0.3 0.3 {}
T {n5_ff} 36590 -35 0 0 0.3 0.3 {}
T {n5_inv} 39550 -35 0 0 0.3 0.3 {}
T {n6_ff} 39910 -35 0 0 0.3 0.3 {}
T {n6_inv} 42870 -35 0 0 0.3 0.3 {}
T {n7_ff} 43230 -35 0 0 0.3 0.3 {}
T {n7_inv} 46190 -35 0 0 0.3 0.3 {}
T {n8_ff} 46550 -35 0 0 0.3 0.3 {}
T {n8_inv} 49510 -35 0 0 0.3 0.3 {}
T {n9_ff} 49870 -35 0 0 0.3 0.3 {}
T {n9_inv} 53550 -35 0 0 0.3 0.3 {}
N 160 950 160 970 {lab=0}
C {devices/gnd.sym} 160 970 0 0 {name=s1 lab=0}
N 160 920 190 920 {lab=0}
C {devices/gnd.sym} 190 920 0 0 {name=s2 lab=0}
N 520 950 520 970 {lab=0}
C {devices/gnd.sym} 520 970 0 0 {name=s3 lab=0}
N 520 920 550 920 {lab=0}
C {devices/gnd.sym} 550 920 0 0 {name=s4 lab=0}
N 2880 950 2880 970 {lab=0}
C {devices/gnd.sym} 2880 970 0 0 {name=s5 lab=0}
N 2880 920 2910 920 {lab=0}
C {devices/gnd.sym} 2910 920 0 0 {name=s6 lab=0}
N 2880 770 2910 770 {lab=0}
C {devices/gnd.sym} 2910 770 0 0 {name=s7 lab=0}
N 3080 620 3110 620 {lab=0}
C {devices/gnd.sym} 3110 620 0 0 {name=s8 lab=0}
N 3080 770 3110 770 {lab=0}
C {devices/gnd.sym} 3110 770 0 0 {name=s9 lab=0}
N 3080 950 3080 970 {lab=0}
C {devices/gnd.sym} 3080 970 0 0 {name=s10 lab=0}
N 3080 920 3110 920 {lab=0}
C {devices/gnd.sym} 3110 920 0 0 {name=s11 lab=0}
N 3640 950 3640 970 {lab=0}
C {devices/gnd.sym} 3640 970 0 0 {name=s12 lab=0}
N 3640 920 3670 920 {lab=0}
C {devices/gnd.sym} 3670 920 0 0 {name=s13 lab=0}
N 3640 770 3670 770 {lab=0}
C {devices/gnd.sym} 3670 770 0 0 {name=s14 lab=0}
N 3840 770 3870 770 {lab=0}
C {devices/gnd.sym} 3870 770 0 0 {name=s15 lab=0}
N 3840 950 3840 970 {lab=0}
C {devices/gnd.sym} 3840 970 0 0 {name=s16 lab=0}
N 3840 920 3870 920 {lab=0}
C {devices/gnd.sym} 3870 920 0 0 {name=s17 lab=0}
N 880 950 880 970 {lab=0}
C {devices/gnd.sym} 880 970 0 0 {name=s18 lab=0}
N 880 920 910 920 {lab=0}
C {devices/gnd.sym} 910 920 0 0 {name=s19 lab=0}
N 880 770 910 770 {lab=0}
C {devices/gnd.sym} 910 770 0 0 {name=s20 lab=0}
N 1440 950 1440 970 {lab=0}
C {devices/gnd.sym} 1440 970 0 0 {name=s21 lab=0}
N 1440 920 1470 920 {lab=0}
C {devices/gnd.sym} 1470 920 0 0 {name=s22 lab=0}
N 160 30 160 10 {lab=VDD}
C {devices/vdd.sym} 160 10 0 0 {name=s23 lab=VDD}
N 160 60 190 60 {lab=VDD}
C {devices/vdd.sym} 190 60 0 0 {name=s24 lab=VDD}
N 520 30 520 10 {lab=VDD}
C {devices/vdd.sym} 520 10 0 0 {name=s25 lab=VDD}
N 520 60 550 60 {lab=VDD}
C {devices/vdd.sym} 550 60 0 0 {name=s26 lab=VDD}
N 2880 30 2880 10 {lab=VDD}
C {devices/vdd.sym} 2880 10 0 0 {name=s27 lab=VDD}
N 2880 60 2910 60 {lab=VDD}
C {devices/vdd.sym} 2910 60 0 0 {name=s28 lab=VDD}
N 2880 210 2910 210 {lab=VDD}
C {devices/vdd.sym} 2910 210 0 0 {name=s29 lab=VDD}
N 3280 210 3310 210 {lab=VDD}
C {devices/vdd.sym} 3310 210 0 0 {name=s30 lab=VDD}
N 3080 30 3080 10 {lab=VDD}
C {devices/vdd.sym} 3080 10 0 0 {name=s31 lab=VDD}
N 3080 60 3110 60 {lab=VDD}
C {devices/vdd.sym} 3110 60 0 0 {name=s32 lab=VDD}
N 3280 30 3280 10 {lab=VDD}
C {devices/vdd.sym} 3280 10 0 0 {name=s33 lab=VDD}
N 3280 60 3310 60 {lab=VDD}
C {devices/vdd.sym} 3310 60 0 0 {name=s34 lab=VDD}
N 3640 30 3640 10 {lab=VDD}
C {devices/vdd.sym} 3640 10 0 0 {name=s35 lab=VDD}
N 3640 60 3670 60 {lab=VDD}
C {devices/vdd.sym} 3670 60 0 0 {name=s36 lab=VDD}
N 3640 210 3670 210 {lab=VDD}
C {devices/vdd.sym} 3670 210 0 0 {name=s37 lab=VDD}
N 3840 210 3870 210 {lab=VDD}
C {devices/vdd.sym} 3870 210 0 0 {name=s38 lab=VDD}
N 3840 30 3840 10 {lab=VDD}
C {devices/vdd.sym} 3840 10 0 0 {name=s39 lab=VDD}
N 3840 60 3870 60 {lab=VDD}
C {devices/vdd.sym} 3870 60 0 0 {name=s40 lab=VDD}
N 880 30 880 10 {lab=VDD}
C {devices/vdd.sym} 880 10 0 0 {name=s41 lab=VDD}
N 880 60 910 60 {lab=VDD}
C {devices/vdd.sym} 910 60 0 0 {name=s42 lab=VDD}
N 1080 30 1080 10 {lab=VDD}
C {devices/vdd.sym} 1080 10 0 0 {name=s43 lab=VDD}
N 1080 60 1110 60 {lab=VDD}
C {devices/vdd.sym} 1110 60 0 0 {name=s44 lab=VDD}
N 1440 30 1440 10 {lab=VDD}
C {devices/vdd.sym} 1440 10 0 0 {name=s45 lab=VDD}
N 1440 60 1470 60 {lab=VDD}
C {devices/vdd.sym} 1470 60 0 0 {name=s46 lab=VDD}
N 1800 950 1800 970 {lab=0}
C {devices/gnd.sym} 1800 970 0 0 {name=s47 lab=0}
N 1800 920 1830 920 {lab=0}
C {devices/gnd.sym} 1830 920 0 0 {name=s48 lab=0}
N 1800 30 1800 10 {lab=VDD}
C {devices/vdd.sym} 1800 10 0 0 {name=s49 lab=VDD}
N 1800 60 1830 60 {lab=VDD}
C {devices/vdd.sym} 1830 60 0 0 {name=s50 lab=VDD}
N 52880 950 52880 970 {lab=0}
C {devices/gnd.sym} 52880 970 0 0 {name=s51 lab=0}
N 52880 920 52910 920 {lab=0}
C {devices/gnd.sym} 52910 920 0 0 {name=s52 lab=0}
N 53240 950 53240 970 {lab=0}
C {devices/gnd.sym} 53240 970 0 0 {name=s53 lab=0}
N 53240 920 53270 920 {lab=0}
C {devices/gnd.sym} 53270 920 0 0 {name=s54 lab=0}
N 53960 950 53960 970 {lab=0}
C {devices/gnd.sym} 53960 970 0 0 {name=s55 lab=0}
N 53960 920 53990 920 {lab=0}
C {devices/gnd.sym} 53990 920 0 0 {name=s56 lab=0}
N 53960 770 53990 770 {lab=0}
C {devices/gnd.sym} 53990 770 0 0 {name=s57 lab=0}
N 54160 620 54190 620 {lab=0}
C {devices/gnd.sym} 54190 620 0 0 {name=s58 lab=0}
N 54160 770 54190 770 {lab=0}
C {devices/gnd.sym} 54190 770 0 0 {name=s59 lab=0}
N 54160 950 54160 970 {lab=0}
C {devices/gnd.sym} 54160 970 0 0 {name=s60 lab=0}
N 54160 920 54190 920 {lab=0}
C {devices/gnd.sym} 54190 920 0 0 {name=s61 lab=0}
N 54720 950 54720 970 {lab=0}
C {devices/gnd.sym} 54720 970 0 0 {name=s62 lab=0}
N 54720 920 54750 920 {lab=0}
C {devices/gnd.sym} 54750 920 0 0 {name=s63 lab=0}
N 54720 770 54750 770 {lab=0}
C {devices/gnd.sym} 54750 770 0 0 {name=s64 lab=0}
N 54920 770 54950 770 {lab=0}
C {devices/gnd.sym} 54950 770 0 0 {name=s65 lab=0}
N 54920 950 54920 970 {lab=0}
C {devices/gnd.sym} 54920 970 0 0 {name=s66 lab=0}
N 54920 920 54950 920 {lab=0}
C {devices/gnd.sym} 54950 920 0 0 {name=s67 lab=0}
N 4200 950 4200 970 {lab=0}
C {devices/gnd.sym} 4200 970 0 0 {name=s68 lab=0}
N 4200 920 4230 920 {lab=0}
C {devices/gnd.sym} 4230 920 0 0 {name=s69 lab=0}
N 4200 770 4230 770 {lab=0}
C {devices/gnd.sym} 4230 770 0 0 {name=s70 lab=0}
N 4760 950 4760 970 {lab=0}
C {devices/gnd.sym} 4760 970 0 0 {name=s71 lab=0}
N 4760 920 4790 920 {lab=0}
C {devices/gnd.sym} 4790 920 0 0 {name=s72 lab=0}
N 52880 30 52880 10 {lab=VDD}
C {devices/vdd.sym} 52880 10 0 0 {name=s73 lab=VDD}
N 52880 60 52910 60 {lab=VDD}
C {devices/vdd.sym} 52910 60 0 0 {name=s74 lab=VDD}
N 53240 30 53240 10 {lab=VDD}
C {devices/vdd.sym} 53240 10 0 0 {name=s75 lab=VDD}
N 53240 60 53270 60 {lab=VDD}
C {devices/vdd.sym} 53270 60 0 0 {name=s76 lab=VDD}
N 53960 30 53960 10 {lab=VDD}
C {devices/vdd.sym} 53960 10 0 0 {name=s77 lab=VDD}
N 53960 60 53990 60 {lab=VDD}
C {devices/vdd.sym} 53990 60 0 0 {name=s78 lab=VDD}
N 53960 210 53990 210 {lab=VDD}
C {devices/vdd.sym} 53990 210 0 0 {name=s79 lab=VDD}
N 54360 210 54390 210 {lab=VDD}
C {devices/vdd.sym} 54390 210 0 0 {name=s80 lab=VDD}
N 54160 30 54160 10 {lab=VDD}
C {devices/vdd.sym} 54160 10 0 0 {name=s81 lab=VDD}
N 54160 60 54190 60 {lab=VDD}
C {devices/vdd.sym} 54190 60 0 0 {name=s82 lab=VDD}
N 54360 30 54360 10 {lab=VDD}
C {devices/vdd.sym} 54360 10 0 0 {name=s83 lab=VDD}
N 54360 60 54390 60 {lab=VDD}
C {devices/vdd.sym} 54390 60 0 0 {name=s84 lab=VDD}
N 54720 30 54720 10 {lab=VDD}
C {devices/vdd.sym} 54720 10 0 0 {name=s85 lab=VDD}
N 54720 60 54750 60 {lab=VDD}
C {devices/vdd.sym} 54750 60 0 0 {name=s86 lab=VDD}
N 54720 210 54750 210 {lab=VDD}
C {devices/vdd.sym} 54750 210 0 0 {name=s87 lab=VDD}
N 54920 210 54950 210 {lab=VDD}
C {devices/vdd.sym} 54950 210 0 0 {name=s88 lab=VDD}
N 54920 30 54920 10 {lab=VDD}
C {devices/vdd.sym} 54920 10 0 0 {name=s89 lab=VDD}
N 54920 60 54950 60 {lab=VDD}
C {devices/vdd.sym} 54950 60 0 0 {name=s90 lab=VDD}
N 4200 30 4200 10 {lab=VDD}
C {devices/vdd.sym} 4200 10 0 0 {name=s91 lab=VDD}
N 4200 60 4230 60 {lab=VDD}
C {devices/vdd.sym} 4230 60 0 0 {name=s92 lab=VDD}
N 4400 30 4400 10 {lab=VDD}
C {devices/vdd.sym} 4400 10 0 0 {name=s93 lab=VDD}
N 4400 60 4430 60 {lab=VDD}
C {devices/vdd.sym} 4430 60 0 0 {name=s94 lab=VDD}
N 4760 30 4760 10 {lab=VDD}
C {devices/vdd.sym} 4760 10 0 0 {name=s95 lab=VDD}
N 4760 60 4790 60 {lab=VDD}
C {devices/vdd.sym} 4790 60 0 0 {name=s96 lab=VDD}
N 5120 950 5120 970 {lab=0}
C {devices/gnd.sym} 5120 970 0 0 {name=s97 lab=0}
N 5120 920 5150 920 {lab=0}
C {devices/gnd.sym} 5150 920 0 0 {name=s98 lab=0}
N 5120 30 5120 10 {lab=VDD}
C {devices/vdd.sym} 5120 10 0 0 {name=s99 lab=VDD}
N 5120 60 5150 60 {lab=VDD}
C {devices/vdd.sym} 5150 60 0 0 {name=s100 lab=VDD}
N 5480 950 5480 970 {lab=0}
C {devices/gnd.sym} 5480 970 0 0 {name=s101 lab=0}
N 5480 920 5510 920 {lab=0}
C {devices/gnd.sym} 5510 920 0 0 {name=s102 lab=0}
N 5840 950 5840 970 {lab=0}
C {devices/gnd.sym} 5840 970 0 0 {name=s103 lab=0}
N 5840 920 5870 920 {lab=0}
C {devices/gnd.sym} 5870 920 0 0 {name=s104 lab=0}
N 8200 950 8200 970 {lab=0}
C {devices/gnd.sym} 8200 970 0 0 {name=s105 lab=0}
N 8200 920 8230 920 {lab=0}
C {devices/gnd.sym} 8230 920 0 0 {name=s106 lab=0}
N 8200 770 8230 770 {lab=0}
C {devices/gnd.sym} 8230 770 0 0 {name=s107 lab=0}
N 8400 620 8430 620 {lab=0}
C {devices/gnd.sym} 8430 620 0 0 {name=s108 lab=0}
N 8400 770 8430 770 {lab=0}
C {devices/gnd.sym} 8430 770 0 0 {name=s109 lab=0}
N 8400 950 8400 970 {lab=0}
C {devices/gnd.sym} 8400 970 0 0 {name=s110 lab=0}
N 8400 920 8430 920 {lab=0}
C {devices/gnd.sym} 8430 920 0 0 {name=s111 lab=0}
N 8960 950 8960 970 {lab=0}
C {devices/gnd.sym} 8960 970 0 0 {name=s112 lab=0}
N 8960 920 8990 920 {lab=0}
C {devices/gnd.sym} 8990 920 0 0 {name=s113 lab=0}
N 8960 770 8990 770 {lab=0}
C {devices/gnd.sym} 8990 770 0 0 {name=s114 lab=0}
N 9160 770 9190 770 {lab=0}
C {devices/gnd.sym} 9190 770 0 0 {name=s115 lab=0}
N 9160 950 9160 970 {lab=0}
C {devices/gnd.sym} 9160 970 0 0 {name=s116 lab=0}
N 9160 920 9190 920 {lab=0}
C {devices/gnd.sym} 9190 920 0 0 {name=s117 lab=0}
N 6200 950 6200 970 {lab=0}
C {devices/gnd.sym} 6200 970 0 0 {name=s118 lab=0}
N 6200 920 6230 920 {lab=0}
C {devices/gnd.sym} 6230 920 0 0 {name=s119 lab=0}
N 6200 770 6230 770 {lab=0}
C {devices/gnd.sym} 6230 770 0 0 {name=s120 lab=0}
N 6760 950 6760 970 {lab=0}
C {devices/gnd.sym} 6760 970 0 0 {name=s121 lab=0}
N 6760 920 6790 920 {lab=0}
C {devices/gnd.sym} 6790 920 0 0 {name=s122 lab=0}
N 5480 30 5480 10 {lab=VDD}
C {devices/vdd.sym} 5480 10 0 0 {name=s123 lab=VDD}
N 5480 60 5510 60 {lab=VDD}
C {devices/vdd.sym} 5510 60 0 0 {name=s124 lab=VDD}
N 5840 30 5840 10 {lab=VDD}
C {devices/vdd.sym} 5840 10 0 0 {name=s125 lab=VDD}
N 5840 60 5870 60 {lab=VDD}
C {devices/vdd.sym} 5870 60 0 0 {name=s126 lab=VDD}
N 8200 30 8200 10 {lab=VDD}
C {devices/vdd.sym} 8200 10 0 0 {name=s127 lab=VDD}
N 8200 60 8230 60 {lab=VDD}
C {devices/vdd.sym} 8230 60 0 0 {name=s128 lab=VDD}
N 8200 210 8230 210 {lab=VDD}
C {devices/vdd.sym} 8230 210 0 0 {name=s129 lab=VDD}
N 8600 210 8630 210 {lab=VDD}
C {devices/vdd.sym} 8630 210 0 0 {name=s130 lab=VDD}
N 8400 30 8400 10 {lab=VDD}
C {devices/vdd.sym} 8400 10 0 0 {name=s131 lab=VDD}
N 8400 60 8430 60 {lab=VDD}
C {devices/vdd.sym} 8430 60 0 0 {name=s132 lab=VDD}
N 8600 30 8600 10 {lab=VDD}
C {devices/vdd.sym} 8600 10 0 0 {name=s133 lab=VDD}
N 8600 60 8630 60 {lab=VDD}
C {devices/vdd.sym} 8630 60 0 0 {name=s134 lab=VDD}
N 8960 30 8960 10 {lab=VDD}
C {devices/vdd.sym} 8960 10 0 0 {name=s135 lab=VDD}
N 8960 60 8990 60 {lab=VDD}
C {devices/vdd.sym} 8990 60 0 0 {name=s136 lab=VDD}
N 8960 210 8990 210 {lab=VDD}
C {devices/vdd.sym} 8990 210 0 0 {name=s137 lab=VDD}
N 9160 210 9190 210 {lab=VDD}
C {devices/vdd.sym} 9190 210 0 0 {name=s138 lab=VDD}
N 9160 30 9160 10 {lab=VDD}
C {devices/vdd.sym} 9160 10 0 0 {name=s139 lab=VDD}
N 9160 60 9190 60 {lab=VDD}
C {devices/vdd.sym} 9190 60 0 0 {name=s140 lab=VDD}
N 6200 30 6200 10 {lab=VDD}
C {devices/vdd.sym} 6200 10 0 0 {name=s141 lab=VDD}
N 6200 60 6230 60 {lab=VDD}
C {devices/vdd.sym} 6230 60 0 0 {name=s142 lab=VDD}
N 6400 30 6400 10 {lab=VDD}
C {devices/vdd.sym} 6400 10 0 0 {name=s143 lab=VDD}
N 6400 60 6430 60 {lab=VDD}
C {devices/vdd.sym} 6430 60 0 0 {name=s144 lab=VDD}
N 6760 30 6760 10 {lab=VDD}
C {devices/vdd.sym} 6760 10 0 0 {name=s145 lab=VDD}
N 6760 60 6790 60 {lab=VDD}
C {devices/vdd.sym} 6790 60 0 0 {name=s146 lab=VDD}
N 7120 950 7120 970 {lab=0}
C {devices/gnd.sym} 7120 970 0 0 {name=s147 lab=0}
N 7120 920 7150 920 {lab=0}
C {devices/gnd.sym} 7150 920 0 0 {name=s148 lab=0}
N 7120 30 7120 10 {lab=VDD}
C {devices/vdd.sym} 7120 10 0 0 {name=s149 lab=VDD}
N 7120 60 7150 60 {lab=VDD}
C {devices/vdd.sym} 7150 60 0 0 {name=s150 lab=VDD}
N 7480 950 7480 970 {lab=0}
C {devices/gnd.sym} 7480 970 0 0 {name=s151 lab=0}
N 7480 920 7510 920 {lab=0}
C {devices/gnd.sym} 7510 920 0 0 {name=s152 lab=0}
N 7840 950 7840 970 {lab=0}
C {devices/gnd.sym} 7840 970 0 0 {name=s153 lab=0}
N 7840 920 7870 920 {lab=0}
C {devices/gnd.sym} 7870 920 0 0 {name=s154 lab=0}
N 11520 950 11520 970 {lab=0}
C {devices/gnd.sym} 11520 970 0 0 {name=s155 lab=0}
N 11520 920 11550 920 {lab=0}
C {devices/gnd.sym} 11550 920 0 0 {name=s156 lab=0}
N 11520 770 11550 770 {lab=0}
C {devices/gnd.sym} 11550 770 0 0 {name=s157 lab=0}
N 11720 620 11750 620 {lab=0}
C {devices/gnd.sym} 11750 620 0 0 {name=s158 lab=0}
N 11720 770 11750 770 {lab=0}
C {devices/gnd.sym} 11750 770 0 0 {name=s159 lab=0}
N 11720 950 11720 970 {lab=0}
C {devices/gnd.sym} 11720 970 0 0 {name=s160 lab=0}
N 11720 920 11750 920 {lab=0}
C {devices/gnd.sym} 11750 920 0 0 {name=s161 lab=0}
N 12280 950 12280 970 {lab=0}
C {devices/gnd.sym} 12280 970 0 0 {name=s162 lab=0}
N 12280 920 12310 920 {lab=0}
C {devices/gnd.sym} 12310 920 0 0 {name=s163 lab=0}
N 12280 770 12310 770 {lab=0}
C {devices/gnd.sym} 12310 770 0 0 {name=s164 lab=0}
N 12480 770 12510 770 {lab=0}
C {devices/gnd.sym} 12510 770 0 0 {name=s165 lab=0}
N 12480 950 12480 970 {lab=0}
C {devices/gnd.sym} 12480 970 0 0 {name=s166 lab=0}
N 12480 920 12510 920 {lab=0}
C {devices/gnd.sym} 12510 920 0 0 {name=s167 lab=0}
N 9520 950 9520 970 {lab=0}
C {devices/gnd.sym} 9520 970 0 0 {name=s168 lab=0}
N 9520 920 9550 920 {lab=0}
C {devices/gnd.sym} 9550 920 0 0 {name=s169 lab=0}
N 9520 770 9550 770 {lab=0}
C {devices/gnd.sym} 9550 770 0 0 {name=s170 lab=0}
N 10080 950 10080 970 {lab=0}
C {devices/gnd.sym} 10080 970 0 0 {name=s171 lab=0}
N 10080 920 10110 920 {lab=0}
C {devices/gnd.sym} 10110 920 0 0 {name=s172 lab=0}
N 7480 30 7480 10 {lab=VDD}
C {devices/vdd.sym} 7480 10 0 0 {name=s173 lab=VDD}
N 7480 60 7510 60 {lab=VDD}
C {devices/vdd.sym} 7510 60 0 0 {name=s174 lab=VDD}
N 7840 30 7840 10 {lab=VDD}
C {devices/vdd.sym} 7840 10 0 0 {name=s175 lab=VDD}
N 7840 60 7870 60 {lab=VDD}
C {devices/vdd.sym} 7870 60 0 0 {name=s176 lab=VDD}
N 11520 30 11520 10 {lab=VDD}
C {devices/vdd.sym} 11520 10 0 0 {name=s177 lab=VDD}
N 11520 60 11550 60 {lab=VDD}
C {devices/vdd.sym} 11550 60 0 0 {name=s178 lab=VDD}
N 11520 210 11550 210 {lab=VDD}
C {devices/vdd.sym} 11550 210 0 0 {name=s179 lab=VDD}
N 11920 210 11950 210 {lab=VDD}
C {devices/vdd.sym} 11950 210 0 0 {name=s180 lab=VDD}
N 11720 30 11720 10 {lab=VDD}
C {devices/vdd.sym} 11720 10 0 0 {name=s181 lab=VDD}
N 11720 60 11750 60 {lab=VDD}
C {devices/vdd.sym} 11750 60 0 0 {name=s182 lab=VDD}
N 11920 30 11920 10 {lab=VDD}
C {devices/vdd.sym} 11920 10 0 0 {name=s183 lab=VDD}
N 11920 60 11950 60 {lab=VDD}
C {devices/vdd.sym} 11950 60 0 0 {name=s184 lab=VDD}
N 12280 30 12280 10 {lab=VDD}
C {devices/vdd.sym} 12280 10 0 0 {name=s185 lab=VDD}
N 12280 60 12310 60 {lab=VDD}
C {devices/vdd.sym} 12310 60 0 0 {name=s186 lab=VDD}
N 12280 210 12310 210 {lab=VDD}
C {devices/vdd.sym} 12310 210 0 0 {name=s187 lab=VDD}
N 12480 210 12510 210 {lab=VDD}
C {devices/vdd.sym} 12510 210 0 0 {name=s188 lab=VDD}
N 12480 30 12480 10 {lab=VDD}
C {devices/vdd.sym} 12480 10 0 0 {name=s189 lab=VDD}
N 12480 60 12510 60 {lab=VDD}
C {devices/vdd.sym} 12510 60 0 0 {name=s190 lab=VDD}
N 9520 30 9520 10 {lab=VDD}
C {devices/vdd.sym} 9520 10 0 0 {name=s191 lab=VDD}
N 9520 60 9550 60 {lab=VDD}
C {devices/vdd.sym} 9550 60 0 0 {name=s192 lab=VDD}
N 9720 30 9720 10 {lab=VDD}
C {devices/vdd.sym} 9720 10 0 0 {name=s193 lab=VDD}
N 9720 60 9750 60 {lab=VDD}
C {devices/vdd.sym} 9750 60 0 0 {name=s194 lab=VDD}
N 10080 30 10080 10 {lab=VDD}
C {devices/vdd.sym} 10080 10 0 0 {name=s195 lab=VDD}
N 10080 60 10110 60 {lab=VDD}
C {devices/vdd.sym} 10110 60 0 0 {name=s196 lab=VDD}
N 10440 950 10440 970 {lab=0}
C {devices/gnd.sym} 10440 970 0 0 {name=s197 lab=0}
N 10440 920 10470 920 {lab=0}
C {devices/gnd.sym} 10470 920 0 0 {name=s198 lab=0}
N 10440 30 10440 10 {lab=VDD}
C {devices/vdd.sym} 10440 10 0 0 {name=s199 lab=VDD}
N 10440 60 10470 60 {lab=VDD}
C {devices/vdd.sym} 10470 60 0 0 {name=s200 lab=VDD}
N 10800 950 10800 970 {lab=0}
C {devices/gnd.sym} 10800 970 0 0 {name=s201 lab=0}
N 10800 920 10830 920 {lab=0}
C {devices/gnd.sym} 10830 920 0 0 {name=s202 lab=0}
N 11160 950 11160 970 {lab=0}
C {devices/gnd.sym} 11160 970 0 0 {name=s203 lab=0}
N 11160 920 11190 920 {lab=0}
C {devices/gnd.sym} 11190 920 0 0 {name=s204 lab=0}
N 14840 950 14840 970 {lab=0}
C {devices/gnd.sym} 14840 970 0 0 {name=s205 lab=0}
N 14840 920 14870 920 {lab=0}
C {devices/gnd.sym} 14870 920 0 0 {name=s206 lab=0}
N 14840 770 14870 770 {lab=0}
C {devices/gnd.sym} 14870 770 0 0 {name=s207 lab=0}
N 15040 620 15070 620 {lab=0}
C {devices/gnd.sym} 15070 620 0 0 {name=s208 lab=0}
N 15040 770 15070 770 {lab=0}
C {devices/gnd.sym} 15070 770 0 0 {name=s209 lab=0}
N 15040 950 15040 970 {lab=0}
C {devices/gnd.sym} 15040 970 0 0 {name=s210 lab=0}
N 15040 920 15070 920 {lab=0}
C {devices/gnd.sym} 15070 920 0 0 {name=s211 lab=0}
N 15600 950 15600 970 {lab=0}
C {devices/gnd.sym} 15600 970 0 0 {name=s212 lab=0}
N 15600 920 15630 920 {lab=0}
C {devices/gnd.sym} 15630 920 0 0 {name=s213 lab=0}
N 15600 770 15630 770 {lab=0}
C {devices/gnd.sym} 15630 770 0 0 {name=s214 lab=0}
N 15800 770 15830 770 {lab=0}
C {devices/gnd.sym} 15830 770 0 0 {name=s215 lab=0}
N 15800 950 15800 970 {lab=0}
C {devices/gnd.sym} 15800 970 0 0 {name=s216 lab=0}
N 15800 920 15830 920 {lab=0}
C {devices/gnd.sym} 15830 920 0 0 {name=s217 lab=0}
N 12840 950 12840 970 {lab=0}
C {devices/gnd.sym} 12840 970 0 0 {name=s218 lab=0}
N 12840 920 12870 920 {lab=0}
C {devices/gnd.sym} 12870 920 0 0 {name=s219 lab=0}
N 12840 770 12870 770 {lab=0}
C {devices/gnd.sym} 12870 770 0 0 {name=s220 lab=0}
N 13400 950 13400 970 {lab=0}
C {devices/gnd.sym} 13400 970 0 0 {name=s221 lab=0}
N 13400 920 13430 920 {lab=0}
C {devices/gnd.sym} 13430 920 0 0 {name=s222 lab=0}
N 10800 30 10800 10 {lab=VDD}
C {devices/vdd.sym} 10800 10 0 0 {name=s223 lab=VDD}
N 10800 60 10830 60 {lab=VDD}
C {devices/vdd.sym} 10830 60 0 0 {name=s224 lab=VDD}
N 11160 30 11160 10 {lab=VDD}
C {devices/vdd.sym} 11160 10 0 0 {name=s225 lab=VDD}
N 11160 60 11190 60 {lab=VDD}
C {devices/vdd.sym} 11190 60 0 0 {name=s226 lab=VDD}
N 14840 30 14840 10 {lab=VDD}
C {devices/vdd.sym} 14840 10 0 0 {name=s227 lab=VDD}
N 14840 60 14870 60 {lab=VDD}
C {devices/vdd.sym} 14870 60 0 0 {name=s228 lab=VDD}
N 14840 210 14870 210 {lab=VDD}
C {devices/vdd.sym} 14870 210 0 0 {name=s229 lab=VDD}
N 15240 210 15270 210 {lab=VDD}
C {devices/vdd.sym} 15270 210 0 0 {name=s230 lab=VDD}
N 15040 30 15040 10 {lab=VDD}
C {devices/vdd.sym} 15040 10 0 0 {name=s231 lab=VDD}
N 15040 60 15070 60 {lab=VDD}
C {devices/vdd.sym} 15070 60 0 0 {name=s232 lab=VDD}
N 15240 30 15240 10 {lab=VDD}
C {devices/vdd.sym} 15240 10 0 0 {name=s233 lab=VDD}
N 15240 60 15270 60 {lab=VDD}
C {devices/vdd.sym} 15270 60 0 0 {name=s234 lab=VDD}
N 15600 30 15600 10 {lab=VDD}
C {devices/vdd.sym} 15600 10 0 0 {name=s235 lab=VDD}
N 15600 60 15630 60 {lab=VDD}
C {devices/vdd.sym} 15630 60 0 0 {name=s236 lab=VDD}
N 15600 210 15630 210 {lab=VDD}
C {devices/vdd.sym} 15630 210 0 0 {name=s237 lab=VDD}
N 15800 210 15830 210 {lab=VDD}
C {devices/vdd.sym} 15830 210 0 0 {name=s238 lab=VDD}
N 15800 30 15800 10 {lab=VDD}
C {devices/vdd.sym} 15800 10 0 0 {name=s239 lab=VDD}
N 15800 60 15830 60 {lab=VDD}
C {devices/vdd.sym} 15830 60 0 0 {name=s240 lab=VDD}
N 12840 30 12840 10 {lab=VDD}
C {devices/vdd.sym} 12840 10 0 0 {name=s241 lab=VDD}
N 12840 60 12870 60 {lab=VDD}
C {devices/vdd.sym} 12870 60 0 0 {name=s242 lab=VDD}
N 13040 30 13040 10 {lab=VDD}
C {devices/vdd.sym} 13040 10 0 0 {name=s243 lab=VDD}
N 13040 60 13070 60 {lab=VDD}
C {devices/vdd.sym} 13070 60 0 0 {name=s244 lab=VDD}
N 13400 30 13400 10 {lab=VDD}
C {devices/vdd.sym} 13400 10 0 0 {name=s245 lab=VDD}
N 13400 60 13430 60 {lab=VDD}
C {devices/vdd.sym} 13430 60 0 0 {name=s246 lab=VDD}
N 13760 950 13760 970 {lab=0}
C {devices/gnd.sym} 13760 970 0 0 {name=s247 lab=0}
N 13760 920 13790 920 {lab=0}
C {devices/gnd.sym} 13790 920 0 0 {name=s248 lab=0}
N 13760 30 13760 10 {lab=VDD}
C {devices/vdd.sym} 13760 10 0 0 {name=s249 lab=VDD}
N 13760 60 13790 60 {lab=VDD}
C {devices/vdd.sym} 13790 60 0 0 {name=s250 lab=VDD}
N 14120 950 14120 970 {lab=0}
C {devices/gnd.sym} 14120 970 0 0 {name=s251 lab=0}
N 14120 920 14150 920 {lab=0}
C {devices/gnd.sym} 14150 920 0 0 {name=s252 lab=0}
N 14480 950 14480 970 {lab=0}
C {devices/gnd.sym} 14480 970 0 0 {name=s253 lab=0}
N 14480 920 14510 920 {lab=0}
C {devices/gnd.sym} 14510 920 0 0 {name=s254 lab=0}
N 18160 950 18160 970 {lab=0}
C {devices/gnd.sym} 18160 970 0 0 {name=s255 lab=0}
N 18160 920 18190 920 {lab=0}
C {devices/gnd.sym} 18190 920 0 0 {name=s256 lab=0}
N 18160 770 18190 770 {lab=0}
C {devices/gnd.sym} 18190 770 0 0 {name=s257 lab=0}
N 18360 620 18390 620 {lab=0}
C {devices/gnd.sym} 18390 620 0 0 {name=s258 lab=0}
N 18360 770 18390 770 {lab=0}
C {devices/gnd.sym} 18390 770 0 0 {name=s259 lab=0}
N 18360 950 18360 970 {lab=0}
C {devices/gnd.sym} 18360 970 0 0 {name=s260 lab=0}
N 18360 920 18390 920 {lab=0}
C {devices/gnd.sym} 18390 920 0 0 {name=s261 lab=0}
N 18920 950 18920 970 {lab=0}
C {devices/gnd.sym} 18920 970 0 0 {name=s262 lab=0}
N 18920 920 18950 920 {lab=0}
C {devices/gnd.sym} 18950 920 0 0 {name=s263 lab=0}
N 18920 770 18950 770 {lab=0}
C {devices/gnd.sym} 18950 770 0 0 {name=s264 lab=0}
N 19120 770 19150 770 {lab=0}
C {devices/gnd.sym} 19150 770 0 0 {name=s265 lab=0}
N 19120 950 19120 970 {lab=0}
C {devices/gnd.sym} 19120 970 0 0 {name=s266 lab=0}
N 19120 920 19150 920 {lab=0}
C {devices/gnd.sym} 19150 920 0 0 {name=s267 lab=0}
N 16160 950 16160 970 {lab=0}
C {devices/gnd.sym} 16160 970 0 0 {name=s268 lab=0}
N 16160 920 16190 920 {lab=0}
C {devices/gnd.sym} 16190 920 0 0 {name=s269 lab=0}
N 16160 770 16190 770 {lab=0}
C {devices/gnd.sym} 16190 770 0 0 {name=s270 lab=0}
N 16720 950 16720 970 {lab=0}
C {devices/gnd.sym} 16720 970 0 0 {name=s271 lab=0}
N 16720 920 16750 920 {lab=0}
C {devices/gnd.sym} 16750 920 0 0 {name=s272 lab=0}
N 14120 30 14120 10 {lab=VDD}
C {devices/vdd.sym} 14120 10 0 0 {name=s273 lab=VDD}
N 14120 60 14150 60 {lab=VDD}
C {devices/vdd.sym} 14150 60 0 0 {name=s274 lab=VDD}
N 14480 30 14480 10 {lab=VDD}
C {devices/vdd.sym} 14480 10 0 0 {name=s275 lab=VDD}
N 14480 60 14510 60 {lab=VDD}
C {devices/vdd.sym} 14510 60 0 0 {name=s276 lab=VDD}
N 18160 30 18160 10 {lab=VDD}
C {devices/vdd.sym} 18160 10 0 0 {name=s277 lab=VDD}
N 18160 60 18190 60 {lab=VDD}
C {devices/vdd.sym} 18190 60 0 0 {name=s278 lab=VDD}
N 18160 210 18190 210 {lab=VDD}
C {devices/vdd.sym} 18190 210 0 0 {name=s279 lab=VDD}
N 18560 210 18590 210 {lab=VDD}
C {devices/vdd.sym} 18590 210 0 0 {name=s280 lab=VDD}
N 18360 30 18360 10 {lab=VDD}
C {devices/vdd.sym} 18360 10 0 0 {name=s281 lab=VDD}
N 18360 60 18390 60 {lab=VDD}
C {devices/vdd.sym} 18390 60 0 0 {name=s282 lab=VDD}
N 18560 30 18560 10 {lab=VDD}
C {devices/vdd.sym} 18560 10 0 0 {name=s283 lab=VDD}
N 18560 60 18590 60 {lab=VDD}
C {devices/vdd.sym} 18590 60 0 0 {name=s284 lab=VDD}
N 18920 30 18920 10 {lab=VDD}
C {devices/vdd.sym} 18920 10 0 0 {name=s285 lab=VDD}
N 18920 60 18950 60 {lab=VDD}
C {devices/vdd.sym} 18950 60 0 0 {name=s286 lab=VDD}
N 18920 210 18950 210 {lab=VDD}
C {devices/vdd.sym} 18950 210 0 0 {name=s287 lab=VDD}
N 19120 210 19150 210 {lab=VDD}
C {devices/vdd.sym} 19150 210 0 0 {name=s288 lab=VDD}
N 19120 30 19120 10 {lab=VDD}
C {devices/vdd.sym} 19120 10 0 0 {name=s289 lab=VDD}
N 19120 60 19150 60 {lab=VDD}
C {devices/vdd.sym} 19150 60 0 0 {name=s290 lab=VDD}
N 16160 30 16160 10 {lab=VDD}
C {devices/vdd.sym} 16160 10 0 0 {name=s291 lab=VDD}
N 16160 60 16190 60 {lab=VDD}
C {devices/vdd.sym} 16190 60 0 0 {name=s292 lab=VDD}
N 16360 30 16360 10 {lab=VDD}
C {devices/vdd.sym} 16360 10 0 0 {name=s293 lab=VDD}
N 16360 60 16390 60 {lab=VDD}
C {devices/vdd.sym} 16390 60 0 0 {name=s294 lab=VDD}
N 16720 30 16720 10 {lab=VDD}
C {devices/vdd.sym} 16720 10 0 0 {name=s295 lab=VDD}
N 16720 60 16750 60 {lab=VDD}
C {devices/vdd.sym} 16750 60 0 0 {name=s296 lab=VDD}
N 17080 950 17080 970 {lab=0}
C {devices/gnd.sym} 17080 970 0 0 {name=s297 lab=0}
N 17080 920 17110 920 {lab=0}
C {devices/gnd.sym} 17110 920 0 0 {name=s298 lab=0}
N 17080 30 17080 10 {lab=VDD}
C {devices/vdd.sym} 17080 10 0 0 {name=s299 lab=VDD}
N 17080 60 17110 60 {lab=VDD}
C {devices/vdd.sym} 17110 60 0 0 {name=s300 lab=VDD}
N 17440 950 17440 970 {lab=0}
C {devices/gnd.sym} 17440 970 0 0 {name=s301 lab=0}
N 17440 920 17470 920 {lab=0}
C {devices/gnd.sym} 17470 920 0 0 {name=s302 lab=0}
N 17800 950 17800 970 {lab=0}
C {devices/gnd.sym} 17800 970 0 0 {name=s303 lab=0}
N 17800 920 17830 920 {lab=0}
C {devices/gnd.sym} 17830 920 0 0 {name=s304 lab=0}
N 21480 950 21480 970 {lab=0}
C {devices/gnd.sym} 21480 970 0 0 {name=s305 lab=0}
N 21480 920 21510 920 {lab=0}
C {devices/gnd.sym} 21510 920 0 0 {name=s306 lab=0}
N 21480 770 21510 770 {lab=0}
C {devices/gnd.sym} 21510 770 0 0 {name=s307 lab=0}
N 21680 620 21710 620 {lab=0}
C {devices/gnd.sym} 21710 620 0 0 {name=s308 lab=0}
N 21680 770 21710 770 {lab=0}
C {devices/gnd.sym} 21710 770 0 0 {name=s309 lab=0}
N 21680 950 21680 970 {lab=0}
C {devices/gnd.sym} 21680 970 0 0 {name=s310 lab=0}
N 21680 920 21710 920 {lab=0}
C {devices/gnd.sym} 21710 920 0 0 {name=s311 lab=0}
N 22240 950 22240 970 {lab=0}
C {devices/gnd.sym} 22240 970 0 0 {name=s312 lab=0}
N 22240 920 22270 920 {lab=0}
C {devices/gnd.sym} 22270 920 0 0 {name=s313 lab=0}
N 22240 770 22270 770 {lab=0}
C {devices/gnd.sym} 22270 770 0 0 {name=s314 lab=0}
N 22440 770 22470 770 {lab=0}
C {devices/gnd.sym} 22470 770 0 0 {name=s315 lab=0}
N 22440 950 22440 970 {lab=0}
C {devices/gnd.sym} 22440 970 0 0 {name=s316 lab=0}
N 22440 920 22470 920 {lab=0}
C {devices/gnd.sym} 22470 920 0 0 {name=s317 lab=0}
N 19480 950 19480 970 {lab=0}
C {devices/gnd.sym} 19480 970 0 0 {name=s318 lab=0}
N 19480 920 19510 920 {lab=0}
C {devices/gnd.sym} 19510 920 0 0 {name=s319 lab=0}
N 19480 770 19510 770 {lab=0}
C {devices/gnd.sym} 19510 770 0 0 {name=s320 lab=0}
N 20040 950 20040 970 {lab=0}
C {devices/gnd.sym} 20040 970 0 0 {name=s321 lab=0}
N 20040 920 20070 920 {lab=0}
C {devices/gnd.sym} 20070 920 0 0 {name=s322 lab=0}
N 17440 30 17440 10 {lab=VDD}
C {devices/vdd.sym} 17440 10 0 0 {name=s323 lab=VDD}
N 17440 60 17470 60 {lab=VDD}
C {devices/vdd.sym} 17470 60 0 0 {name=s324 lab=VDD}
N 17800 30 17800 10 {lab=VDD}
C {devices/vdd.sym} 17800 10 0 0 {name=s325 lab=VDD}
N 17800 60 17830 60 {lab=VDD}
C {devices/vdd.sym} 17830 60 0 0 {name=s326 lab=VDD}
N 21480 30 21480 10 {lab=VDD}
C {devices/vdd.sym} 21480 10 0 0 {name=s327 lab=VDD}
N 21480 60 21510 60 {lab=VDD}
C {devices/vdd.sym} 21510 60 0 0 {name=s328 lab=VDD}
N 21480 210 21510 210 {lab=VDD}
C {devices/vdd.sym} 21510 210 0 0 {name=s329 lab=VDD}
N 21880 210 21910 210 {lab=VDD}
C {devices/vdd.sym} 21910 210 0 0 {name=s330 lab=VDD}
N 21680 30 21680 10 {lab=VDD}
C {devices/vdd.sym} 21680 10 0 0 {name=s331 lab=VDD}
N 21680 60 21710 60 {lab=VDD}
C {devices/vdd.sym} 21710 60 0 0 {name=s332 lab=VDD}
N 21880 30 21880 10 {lab=VDD}
C {devices/vdd.sym} 21880 10 0 0 {name=s333 lab=VDD}
N 21880 60 21910 60 {lab=VDD}
C {devices/vdd.sym} 21910 60 0 0 {name=s334 lab=VDD}
N 22240 30 22240 10 {lab=VDD}
C {devices/vdd.sym} 22240 10 0 0 {name=s335 lab=VDD}
N 22240 60 22270 60 {lab=VDD}
C {devices/vdd.sym} 22270 60 0 0 {name=s336 lab=VDD}
N 22240 210 22270 210 {lab=VDD}
C {devices/vdd.sym} 22270 210 0 0 {name=s337 lab=VDD}
N 22440 210 22470 210 {lab=VDD}
C {devices/vdd.sym} 22470 210 0 0 {name=s338 lab=VDD}
N 22440 30 22440 10 {lab=VDD}
C {devices/vdd.sym} 22440 10 0 0 {name=s339 lab=VDD}
N 22440 60 22470 60 {lab=VDD}
C {devices/vdd.sym} 22470 60 0 0 {name=s340 lab=VDD}
N 19480 30 19480 10 {lab=VDD}
C {devices/vdd.sym} 19480 10 0 0 {name=s341 lab=VDD}
N 19480 60 19510 60 {lab=VDD}
C {devices/vdd.sym} 19510 60 0 0 {name=s342 lab=VDD}
N 19680 30 19680 10 {lab=VDD}
C {devices/vdd.sym} 19680 10 0 0 {name=s343 lab=VDD}
N 19680 60 19710 60 {lab=VDD}
C {devices/vdd.sym} 19710 60 0 0 {name=s344 lab=VDD}
N 20040 30 20040 10 {lab=VDD}
C {devices/vdd.sym} 20040 10 0 0 {name=s345 lab=VDD}
N 20040 60 20070 60 {lab=VDD}
C {devices/vdd.sym} 20070 60 0 0 {name=s346 lab=VDD}
N 20400 950 20400 970 {lab=0}
C {devices/gnd.sym} 20400 970 0 0 {name=s347 lab=0}
N 20400 920 20430 920 {lab=0}
C {devices/gnd.sym} 20430 920 0 0 {name=s348 lab=0}
N 20400 30 20400 10 {lab=VDD}
C {devices/vdd.sym} 20400 10 0 0 {name=s349 lab=VDD}
N 20400 60 20430 60 {lab=VDD}
C {devices/vdd.sym} 20430 60 0 0 {name=s350 lab=VDD}
N 20760 950 20760 970 {lab=0}
C {devices/gnd.sym} 20760 970 0 0 {name=s351 lab=0}
N 20760 920 20790 920 {lab=0}
C {devices/gnd.sym} 20790 920 0 0 {name=s352 lab=0}
N 21120 950 21120 970 {lab=0}
C {devices/gnd.sym} 21120 970 0 0 {name=s353 lab=0}
N 21120 920 21150 920 {lab=0}
C {devices/gnd.sym} 21150 920 0 0 {name=s354 lab=0}
N 24080 950 24080 970 {lab=0}
C {devices/gnd.sym} 24080 970 0 0 {name=s355 lab=0}
N 24080 920 24110 920 {lab=0}
C {devices/gnd.sym} 24110 920 0 0 {name=s356 lab=0}
N 24080 770 24110 770 {lab=0}
C {devices/gnd.sym} 24110 770 0 0 {name=s357 lab=0}
N 24280 620 24310 620 {lab=0}
C {devices/gnd.sym} 24310 620 0 0 {name=s358 lab=0}
N 24280 770 24310 770 {lab=0}
C {devices/gnd.sym} 24310 770 0 0 {name=s359 lab=0}
N 24280 950 24280 970 {lab=0}
C {devices/gnd.sym} 24280 970 0 0 {name=s360 lab=0}
N 24280 920 24310 920 {lab=0}
C {devices/gnd.sym} 24310 920 0 0 {name=s361 lab=0}
N 24840 950 24840 970 {lab=0}
C {devices/gnd.sym} 24840 970 0 0 {name=s362 lab=0}
N 24840 920 24870 920 {lab=0}
C {devices/gnd.sym} 24870 920 0 0 {name=s363 lab=0}
N 24840 770 24870 770 {lab=0}
C {devices/gnd.sym} 24870 770 0 0 {name=s364 lab=0}
N 25040 770 25070 770 {lab=0}
C {devices/gnd.sym} 25070 770 0 0 {name=s365 lab=0}
N 25040 950 25040 970 {lab=0}
C {devices/gnd.sym} 25040 970 0 0 {name=s366 lab=0}
N 25040 920 25070 920 {lab=0}
C {devices/gnd.sym} 25070 920 0 0 {name=s367 lab=0}
N 22800 950 22800 970 {lab=0}
C {devices/gnd.sym} 22800 970 0 0 {name=s368 lab=0}
N 22800 920 22830 920 {lab=0}
C {devices/gnd.sym} 22830 920 0 0 {name=s369 lab=0}
N 22800 770 22830 770 {lab=0}
C {devices/gnd.sym} 22830 770 0 0 {name=s370 lab=0}
N 23360 950 23360 970 {lab=0}
C {devices/gnd.sym} 23360 970 0 0 {name=s371 lab=0}
N 23360 920 23390 920 {lab=0}
C {devices/gnd.sym} 23390 920 0 0 {name=s372 lab=0}
N 20760 30 20760 10 {lab=VDD}
C {devices/vdd.sym} 20760 10 0 0 {name=s373 lab=VDD}
N 20760 60 20790 60 {lab=VDD}
C {devices/vdd.sym} 20790 60 0 0 {name=s374 lab=VDD}
N 21120 30 21120 10 {lab=VDD}
C {devices/vdd.sym} 21120 10 0 0 {name=s375 lab=VDD}
N 21120 60 21150 60 {lab=VDD}
C {devices/vdd.sym} 21150 60 0 0 {name=s376 lab=VDD}
N 24080 30 24080 10 {lab=VDD}
C {devices/vdd.sym} 24080 10 0 0 {name=s377 lab=VDD}
N 24080 60 24110 60 {lab=VDD}
C {devices/vdd.sym} 24110 60 0 0 {name=s378 lab=VDD}
N 24080 210 24110 210 {lab=VDD}
C {devices/vdd.sym} 24110 210 0 0 {name=s379 lab=VDD}
N 24480 210 24510 210 {lab=VDD}
C {devices/vdd.sym} 24510 210 0 0 {name=s380 lab=VDD}
N 24280 30 24280 10 {lab=VDD}
C {devices/vdd.sym} 24280 10 0 0 {name=s381 lab=VDD}
N 24280 60 24310 60 {lab=VDD}
C {devices/vdd.sym} 24310 60 0 0 {name=s382 lab=VDD}
N 24480 30 24480 10 {lab=VDD}
C {devices/vdd.sym} 24480 10 0 0 {name=s383 lab=VDD}
N 24480 60 24510 60 {lab=VDD}
C {devices/vdd.sym} 24510 60 0 0 {name=s384 lab=VDD}
N 24840 30 24840 10 {lab=VDD}
C {devices/vdd.sym} 24840 10 0 0 {name=s385 lab=VDD}
N 24840 60 24870 60 {lab=VDD}
C {devices/vdd.sym} 24870 60 0 0 {name=s386 lab=VDD}
N 24840 210 24870 210 {lab=VDD}
C {devices/vdd.sym} 24870 210 0 0 {name=s387 lab=VDD}
N 25040 210 25070 210 {lab=VDD}
C {devices/vdd.sym} 25070 210 0 0 {name=s388 lab=VDD}
N 25040 30 25040 10 {lab=VDD}
C {devices/vdd.sym} 25040 10 0 0 {name=s389 lab=VDD}
N 25040 60 25070 60 {lab=VDD}
C {devices/vdd.sym} 25070 60 0 0 {name=s390 lab=VDD}
N 22800 30 22800 10 {lab=VDD}
C {devices/vdd.sym} 22800 10 0 0 {name=s391 lab=VDD}
N 22800 60 22830 60 {lab=VDD}
C {devices/vdd.sym} 22830 60 0 0 {name=s392 lab=VDD}
N 23000 30 23000 10 {lab=VDD}
C {devices/vdd.sym} 23000 10 0 0 {name=s393 lab=VDD}
N 23000 60 23030 60 {lab=VDD}
C {devices/vdd.sym} 23030 60 0 0 {name=s394 lab=VDD}
N 23360 30 23360 10 {lab=VDD}
C {devices/vdd.sym} 23360 10 0 0 {name=s395 lab=VDD}
N 23360 60 23390 60 {lab=VDD}
C {devices/vdd.sym} 23390 60 0 0 {name=s396 lab=VDD}
N 23720 950 23720 970 {lab=0}
C {devices/gnd.sym} 23720 970 0 0 {name=s397 lab=0}
N 23720 920 23750 920 {lab=0}
C {devices/gnd.sym} 23750 920 0 0 {name=s398 lab=0}
N 23720 30 23720 10 {lab=VDD}
C {devices/vdd.sym} 23720 10 0 0 {name=s399 lab=VDD}
N 23720 60 23750 60 {lab=VDD}
C {devices/vdd.sym} 23750 60 0 0 {name=s400 lab=VDD}
N 2160 950 2160 970 {lab=0}
C {devices/gnd.sym} 2160 970 0 0 {name=s401 lab=0}
N 2160 920 2190 920 {lab=0}
C {devices/gnd.sym} 2190 920 0 0 {name=s402 lab=0}
N 2520 950 2520 970 {lab=0}
C {devices/gnd.sym} 2520 970 0 0 {name=s403 lab=0}
N 2520 920 2550 920 {lab=0}
C {devices/gnd.sym} 2550 920 0 0 {name=s404 lab=0}
N 27400 950 27400 970 {lab=0}
C {devices/gnd.sym} 27400 970 0 0 {name=s405 lab=0}
N 27400 920 27430 920 {lab=0}
C {devices/gnd.sym} 27430 920 0 0 {name=s406 lab=0}
N 27400 770 27430 770 {lab=0}
C {devices/gnd.sym} 27430 770 0 0 {name=s407 lab=0}
N 27600 620 27630 620 {lab=0}
C {devices/gnd.sym} 27630 620 0 0 {name=s408 lab=0}
N 27600 770 27630 770 {lab=0}
C {devices/gnd.sym} 27630 770 0 0 {name=s409 lab=0}
N 27600 950 27600 970 {lab=0}
C {devices/gnd.sym} 27600 970 0 0 {name=s410 lab=0}
N 27600 920 27630 920 {lab=0}
C {devices/gnd.sym} 27630 920 0 0 {name=s411 lab=0}
N 28160 950 28160 970 {lab=0}
C {devices/gnd.sym} 28160 970 0 0 {name=s412 lab=0}
N 28160 920 28190 920 {lab=0}
C {devices/gnd.sym} 28190 920 0 0 {name=s413 lab=0}
N 28160 770 28190 770 {lab=0}
C {devices/gnd.sym} 28190 770 0 0 {name=s414 lab=0}
N 28360 770 28390 770 {lab=0}
C {devices/gnd.sym} 28390 770 0 0 {name=s415 lab=0}
N 28360 950 28360 970 {lab=0}
C {devices/gnd.sym} 28360 970 0 0 {name=s416 lab=0}
N 28360 920 28390 920 {lab=0}
C {devices/gnd.sym} 28390 920 0 0 {name=s417 lab=0}
N 25400 950 25400 970 {lab=0}
C {devices/gnd.sym} 25400 970 0 0 {name=s418 lab=0}
N 25400 920 25430 920 {lab=0}
C {devices/gnd.sym} 25430 920 0 0 {name=s419 lab=0}
N 25400 770 25430 770 {lab=0}
C {devices/gnd.sym} 25430 770 0 0 {name=s420 lab=0}
N 25960 950 25960 970 {lab=0}
C {devices/gnd.sym} 25960 970 0 0 {name=s421 lab=0}
N 25960 920 25990 920 {lab=0}
C {devices/gnd.sym} 25990 920 0 0 {name=s422 lab=0}
N 2160 30 2160 10 {lab=VDD}
C {devices/vdd.sym} 2160 10 0 0 {name=s423 lab=VDD}
N 2160 60 2190 60 {lab=VDD}
C {devices/vdd.sym} 2190 60 0 0 {name=s424 lab=VDD}
N 2520 30 2520 10 {lab=VDD}
C {devices/vdd.sym} 2520 10 0 0 {name=s425 lab=VDD}
N 2520 60 2550 60 {lab=VDD}
C {devices/vdd.sym} 2550 60 0 0 {name=s426 lab=VDD}
N 27400 30 27400 10 {lab=VDD}
C {devices/vdd.sym} 27400 10 0 0 {name=s427 lab=VDD}
N 27400 60 27430 60 {lab=VDD}
C {devices/vdd.sym} 27430 60 0 0 {name=s428 lab=VDD}
N 27400 210 27430 210 {lab=VDD}
C {devices/vdd.sym} 27430 210 0 0 {name=s429 lab=VDD}
N 27800 210 27830 210 {lab=VDD}
C {devices/vdd.sym} 27830 210 0 0 {name=s430 lab=VDD}
N 27600 30 27600 10 {lab=VDD}
C {devices/vdd.sym} 27600 10 0 0 {name=s431 lab=VDD}
N 27600 60 27630 60 {lab=VDD}
C {devices/vdd.sym} 27630 60 0 0 {name=s432 lab=VDD}
N 27800 30 27800 10 {lab=VDD}
C {devices/vdd.sym} 27800 10 0 0 {name=s433 lab=VDD}
N 27800 60 27830 60 {lab=VDD}
C {devices/vdd.sym} 27830 60 0 0 {name=s434 lab=VDD}
N 28160 30 28160 10 {lab=VDD}
C {devices/vdd.sym} 28160 10 0 0 {name=s435 lab=VDD}
N 28160 60 28190 60 {lab=VDD}
C {devices/vdd.sym} 28190 60 0 0 {name=s436 lab=VDD}
N 28160 210 28190 210 {lab=VDD}
C {devices/vdd.sym} 28190 210 0 0 {name=s437 lab=VDD}
N 28360 210 28390 210 {lab=VDD}
C {devices/vdd.sym} 28390 210 0 0 {name=s438 lab=VDD}
N 28360 30 28360 10 {lab=VDD}
C {devices/vdd.sym} 28360 10 0 0 {name=s439 lab=VDD}
N 28360 60 28390 60 {lab=VDD}
C {devices/vdd.sym} 28390 60 0 0 {name=s440 lab=VDD}
N 25400 30 25400 10 {lab=VDD}
C {devices/vdd.sym} 25400 10 0 0 {name=s441 lab=VDD}
N 25400 60 25430 60 {lab=VDD}
C {devices/vdd.sym} 25430 60 0 0 {name=s442 lab=VDD}
N 25600 30 25600 10 {lab=VDD}
C {devices/vdd.sym} 25600 10 0 0 {name=s443 lab=VDD}
N 25600 60 25630 60 {lab=VDD}
C {devices/vdd.sym} 25630 60 0 0 {name=s444 lab=VDD}
N 25960 30 25960 10 {lab=VDD}
C {devices/vdd.sym} 25960 10 0 0 {name=s445 lab=VDD}
N 25960 60 25990 60 {lab=VDD}
C {devices/vdd.sym} 25990 60 0 0 {name=s446 lab=VDD}
N 26320 950 26320 970 {lab=0}
C {devices/gnd.sym} 26320 970 0 0 {name=s447 lab=0}
N 26320 920 26350 920 {lab=0}
C {devices/gnd.sym} 26350 920 0 0 {name=s448 lab=0}
N 26320 30 26320 10 {lab=VDD}
C {devices/vdd.sym} 26320 10 0 0 {name=s449 lab=VDD}
N 26320 60 26350 60 {lab=VDD}
C {devices/vdd.sym} 26350 60 0 0 {name=s450 lab=VDD}
N 26680 950 26680 970 {lab=0}
C {devices/gnd.sym} 26680 970 0 0 {name=s451 lab=0}
N 26680 920 26710 920 {lab=0}
C {devices/gnd.sym} 26710 920 0 0 {name=s452 lab=0}
N 27040 950 27040 970 {lab=0}
C {devices/gnd.sym} 27040 970 0 0 {name=s453 lab=0}
N 27040 920 27070 920 {lab=0}
C {devices/gnd.sym} 27070 920 0 0 {name=s454 lab=0}
N 30720 950 30720 970 {lab=0}
C {devices/gnd.sym} 30720 970 0 0 {name=s455 lab=0}
N 30720 920 30750 920 {lab=0}
C {devices/gnd.sym} 30750 920 0 0 {name=s456 lab=0}
N 30720 770 30750 770 {lab=0}
C {devices/gnd.sym} 30750 770 0 0 {name=s457 lab=0}
N 30920 620 30950 620 {lab=0}
C {devices/gnd.sym} 30950 620 0 0 {name=s458 lab=0}
N 30920 770 30950 770 {lab=0}
C {devices/gnd.sym} 30950 770 0 0 {name=s459 lab=0}
N 30920 950 30920 970 {lab=0}
C {devices/gnd.sym} 30920 970 0 0 {name=s460 lab=0}
N 30920 920 30950 920 {lab=0}
C {devices/gnd.sym} 30950 920 0 0 {name=s461 lab=0}
N 31480 950 31480 970 {lab=0}
C {devices/gnd.sym} 31480 970 0 0 {name=s462 lab=0}
N 31480 920 31510 920 {lab=0}
C {devices/gnd.sym} 31510 920 0 0 {name=s463 lab=0}
N 31480 770 31510 770 {lab=0}
C {devices/gnd.sym} 31510 770 0 0 {name=s464 lab=0}
N 31680 770 31710 770 {lab=0}
C {devices/gnd.sym} 31710 770 0 0 {name=s465 lab=0}
N 31680 950 31680 970 {lab=0}
C {devices/gnd.sym} 31680 970 0 0 {name=s466 lab=0}
N 31680 920 31710 920 {lab=0}
C {devices/gnd.sym} 31710 920 0 0 {name=s467 lab=0}
N 28720 950 28720 970 {lab=0}
C {devices/gnd.sym} 28720 970 0 0 {name=s468 lab=0}
N 28720 920 28750 920 {lab=0}
C {devices/gnd.sym} 28750 920 0 0 {name=s469 lab=0}
N 28720 770 28750 770 {lab=0}
C {devices/gnd.sym} 28750 770 0 0 {name=s470 lab=0}
N 29280 950 29280 970 {lab=0}
C {devices/gnd.sym} 29280 970 0 0 {name=s471 lab=0}
N 29280 920 29310 920 {lab=0}
C {devices/gnd.sym} 29310 920 0 0 {name=s472 lab=0}
N 26680 30 26680 10 {lab=VDD}
C {devices/vdd.sym} 26680 10 0 0 {name=s473 lab=VDD}
N 26680 60 26710 60 {lab=VDD}
C {devices/vdd.sym} 26710 60 0 0 {name=s474 lab=VDD}
N 27040 30 27040 10 {lab=VDD}
C {devices/vdd.sym} 27040 10 0 0 {name=s475 lab=VDD}
N 27040 60 27070 60 {lab=VDD}
C {devices/vdd.sym} 27070 60 0 0 {name=s476 lab=VDD}
N 30720 30 30720 10 {lab=VDD}
C {devices/vdd.sym} 30720 10 0 0 {name=s477 lab=VDD}
N 30720 60 30750 60 {lab=VDD}
C {devices/vdd.sym} 30750 60 0 0 {name=s478 lab=VDD}
N 30720 210 30750 210 {lab=VDD}
C {devices/vdd.sym} 30750 210 0 0 {name=s479 lab=VDD}
N 31120 210 31150 210 {lab=VDD}
C {devices/vdd.sym} 31150 210 0 0 {name=s480 lab=VDD}
N 30920 30 30920 10 {lab=VDD}
C {devices/vdd.sym} 30920 10 0 0 {name=s481 lab=VDD}
N 30920 60 30950 60 {lab=VDD}
C {devices/vdd.sym} 30950 60 0 0 {name=s482 lab=VDD}
N 31120 30 31120 10 {lab=VDD}
C {devices/vdd.sym} 31120 10 0 0 {name=s483 lab=VDD}
N 31120 60 31150 60 {lab=VDD}
C {devices/vdd.sym} 31150 60 0 0 {name=s484 lab=VDD}
N 31480 30 31480 10 {lab=VDD}
C {devices/vdd.sym} 31480 10 0 0 {name=s485 lab=VDD}
N 31480 60 31510 60 {lab=VDD}
C {devices/vdd.sym} 31510 60 0 0 {name=s486 lab=VDD}
N 31480 210 31510 210 {lab=VDD}
C {devices/vdd.sym} 31510 210 0 0 {name=s487 lab=VDD}
N 31680 210 31710 210 {lab=VDD}
C {devices/vdd.sym} 31710 210 0 0 {name=s488 lab=VDD}
N 31680 30 31680 10 {lab=VDD}
C {devices/vdd.sym} 31680 10 0 0 {name=s489 lab=VDD}
N 31680 60 31710 60 {lab=VDD}
C {devices/vdd.sym} 31710 60 0 0 {name=s490 lab=VDD}
N 28720 30 28720 10 {lab=VDD}
C {devices/vdd.sym} 28720 10 0 0 {name=s491 lab=VDD}
N 28720 60 28750 60 {lab=VDD}
C {devices/vdd.sym} 28750 60 0 0 {name=s492 lab=VDD}
N 28920 30 28920 10 {lab=VDD}
C {devices/vdd.sym} 28920 10 0 0 {name=s493 lab=VDD}
N 28920 60 28950 60 {lab=VDD}
C {devices/vdd.sym} 28950 60 0 0 {name=s494 lab=VDD}
N 29280 30 29280 10 {lab=VDD}
C {devices/vdd.sym} 29280 10 0 0 {name=s495 lab=VDD}
N 29280 60 29310 60 {lab=VDD}
C {devices/vdd.sym} 29310 60 0 0 {name=s496 lab=VDD}
N 29640 950 29640 970 {lab=0}
C {devices/gnd.sym} 29640 970 0 0 {name=s497 lab=0}
N 29640 920 29670 920 {lab=0}
C {devices/gnd.sym} 29670 920 0 0 {name=s498 lab=0}
N 29640 30 29640 10 {lab=VDD}
C {devices/vdd.sym} 29640 10 0 0 {name=s499 lab=VDD}
N 29640 60 29670 60 {lab=VDD}
C {devices/vdd.sym} 29670 60 0 0 {name=s500 lab=VDD}
N 30000 950 30000 970 {lab=0}
C {devices/gnd.sym} 30000 970 0 0 {name=s501 lab=0}
N 30000 920 30030 920 {lab=0}
C {devices/gnd.sym} 30030 920 0 0 {name=s502 lab=0}
N 30360 950 30360 970 {lab=0}
C {devices/gnd.sym} 30360 970 0 0 {name=s503 lab=0}
N 30360 920 30390 920 {lab=0}
C {devices/gnd.sym} 30390 920 0 0 {name=s504 lab=0}
N 34040 950 34040 970 {lab=0}
C {devices/gnd.sym} 34040 970 0 0 {name=s505 lab=0}
N 34040 920 34070 920 {lab=0}
C {devices/gnd.sym} 34070 920 0 0 {name=s506 lab=0}
N 34040 770 34070 770 {lab=0}
C {devices/gnd.sym} 34070 770 0 0 {name=s507 lab=0}
N 34240 620 34270 620 {lab=0}
C {devices/gnd.sym} 34270 620 0 0 {name=s508 lab=0}
N 34240 770 34270 770 {lab=0}
C {devices/gnd.sym} 34270 770 0 0 {name=s509 lab=0}
N 34240 950 34240 970 {lab=0}
C {devices/gnd.sym} 34240 970 0 0 {name=s510 lab=0}
N 34240 920 34270 920 {lab=0}
C {devices/gnd.sym} 34270 920 0 0 {name=s511 lab=0}
N 34800 950 34800 970 {lab=0}
C {devices/gnd.sym} 34800 970 0 0 {name=s512 lab=0}
N 34800 920 34830 920 {lab=0}
C {devices/gnd.sym} 34830 920 0 0 {name=s513 lab=0}
N 34800 770 34830 770 {lab=0}
C {devices/gnd.sym} 34830 770 0 0 {name=s514 lab=0}
N 35000 770 35030 770 {lab=0}
C {devices/gnd.sym} 35030 770 0 0 {name=s515 lab=0}
N 35000 950 35000 970 {lab=0}
C {devices/gnd.sym} 35000 970 0 0 {name=s516 lab=0}
N 35000 920 35030 920 {lab=0}
C {devices/gnd.sym} 35030 920 0 0 {name=s517 lab=0}
N 32040 950 32040 970 {lab=0}
C {devices/gnd.sym} 32040 970 0 0 {name=s518 lab=0}
N 32040 920 32070 920 {lab=0}
C {devices/gnd.sym} 32070 920 0 0 {name=s519 lab=0}
N 32040 770 32070 770 {lab=0}
C {devices/gnd.sym} 32070 770 0 0 {name=s520 lab=0}
N 32600 950 32600 970 {lab=0}
C {devices/gnd.sym} 32600 970 0 0 {name=s521 lab=0}
N 32600 920 32630 920 {lab=0}
C {devices/gnd.sym} 32630 920 0 0 {name=s522 lab=0}
N 30000 30 30000 10 {lab=VDD}
C {devices/vdd.sym} 30000 10 0 0 {name=s523 lab=VDD}
N 30000 60 30030 60 {lab=VDD}
C {devices/vdd.sym} 30030 60 0 0 {name=s524 lab=VDD}
N 30360 30 30360 10 {lab=VDD}
C {devices/vdd.sym} 30360 10 0 0 {name=s525 lab=VDD}
N 30360 60 30390 60 {lab=VDD}
C {devices/vdd.sym} 30390 60 0 0 {name=s526 lab=VDD}
N 34040 30 34040 10 {lab=VDD}
C {devices/vdd.sym} 34040 10 0 0 {name=s527 lab=VDD}
N 34040 60 34070 60 {lab=VDD}
C {devices/vdd.sym} 34070 60 0 0 {name=s528 lab=VDD}
N 34040 210 34070 210 {lab=VDD}
C {devices/vdd.sym} 34070 210 0 0 {name=s529 lab=VDD}
N 34440 210 34470 210 {lab=VDD}
C {devices/vdd.sym} 34470 210 0 0 {name=s530 lab=VDD}
N 34240 30 34240 10 {lab=VDD}
C {devices/vdd.sym} 34240 10 0 0 {name=s531 lab=VDD}
N 34240 60 34270 60 {lab=VDD}
C {devices/vdd.sym} 34270 60 0 0 {name=s532 lab=VDD}
N 34440 30 34440 10 {lab=VDD}
C {devices/vdd.sym} 34440 10 0 0 {name=s533 lab=VDD}
N 34440 60 34470 60 {lab=VDD}
C {devices/vdd.sym} 34470 60 0 0 {name=s534 lab=VDD}
N 34800 30 34800 10 {lab=VDD}
C {devices/vdd.sym} 34800 10 0 0 {name=s535 lab=VDD}
N 34800 60 34830 60 {lab=VDD}
C {devices/vdd.sym} 34830 60 0 0 {name=s536 lab=VDD}
N 34800 210 34830 210 {lab=VDD}
C {devices/vdd.sym} 34830 210 0 0 {name=s537 lab=VDD}
N 35000 210 35030 210 {lab=VDD}
C {devices/vdd.sym} 35030 210 0 0 {name=s538 lab=VDD}
N 35000 30 35000 10 {lab=VDD}
C {devices/vdd.sym} 35000 10 0 0 {name=s539 lab=VDD}
N 35000 60 35030 60 {lab=VDD}
C {devices/vdd.sym} 35030 60 0 0 {name=s540 lab=VDD}
N 32040 30 32040 10 {lab=VDD}
C {devices/vdd.sym} 32040 10 0 0 {name=s541 lab=VDD}
N 32040 60 32070 60 {lab=VDD}
C {devices/vdd.sym} 32070 60 0 0 {name=s542 lab=VDD}
N 32240 30 32240 10 {lab=VDD}
C {devices/vdd.sym} 32240 10 0 0 {name=s543 lab=VDD}
N 32240 60 32270 60 {lab=VDD}
C {devices/vdd.sym} 32270 60 0 0 {name=s544 lab=VDD}
N 32600 30 32600 10 {lab=VDD}
C {devices/vdd.sym} 32600 10 0 0 {name=s545 lab=VDD}
N 32600 60 32630 60 {lab=VDD}
C {devices/vdd.sym} 32630 60 0 0 {name=s546 lab=VDD}
N 32960 950 32960 970 {lab=0}
C {devices/gnd.sym} 32960 970 0 0 {name=s547 lab=0}
N 32960 920 32990 920 {lab=0}
C {devices/gnd.sym} 32990 920 0 0 {name=s548 lab=0}
N 32960 30 32960 10 {lab=VDD}
C {devices/vdd.sym} 32960 10 0 0 {name=s549 lab=VDD}
N 32960 60 32990 60 {lab=VDD}
C {devices/vdd.sym} 32990 60 0 0 {name=s550 lab=VDD}
N 33320 950 33320 970 {lab=0}
C {devices/gnd.sym} 33320 970 0 0 {name=s551 lab=0}
N 33320 920 33350 920 {lab=0}
C {devices/gnd.sym} 33350 920 0 0 {name=s552 lab=0}
N 33680 950 33680 970 {lab=0}
C {devices/gnd.sym} 33680 970 0 0 {name=s553 lab=0}
N 33680 920 33710 920 {lab=0}
C {devices/gnd.sym} 33710 920 0 0 {name=s554 lab=0}
N 37360 950 37360 970 {lab=0}
C {devices/gnd.sym} 37360 970 0 0 {name=s555 lab=0}
N 37360 920 37390 920 {lab=0}
C {devices/gnd.sym} 37390 920 0 0 {name=s556 lab=0}
N 37360 770 37390 770 {lab=0}
C {devices/gnd.sym} 37390 770 0 0 {name=s557 lab=0}
N 37560 620 37590 620 {lab=0}
C {devices/gnd.sym} 37590 620 0 0 {name=s558 lab=0}
N 37560 770 37590 770 {lab=0}
C {devices/gnd.sym} 37590 770 0 0 {name=s559 lab=0}
N 37560 950 37560 970 {lab=0}
C {devices/gnd.sym} 37560 970 0 0 {name=s560 lab=0}
N 37560 920 37590 920 {lab=0}
C {devices/gnd.sym} 37590 920 0 0 {name=s561 lab=0}
N 38120 950 38120 970 {lab=0}
C {devices/gnd.sym} 38120 970 0 0 {name=s562 lab=0}
N 38120 920 38150 920 {lab=0}
C {devices/gnd.sym} 38150 920 0 0 {name=s563 lab=0}
N 38120 770 38150 770 {lab=0}
C {devices/gnd.sym} 38150 770 0 0 {name=s564 lab=0}
N 38320 770 38350 770 {lab=0}
C {devices/gnd.sym} 38350 770 0 0 {name=s565 lab=0}
N 38320 950 38320 970 {lab=0}
C {devices/gnd.sym} 38320 970 0 0 {name=s566 lab=0}
N 38320 920 38350 920 {lab=0}
C {devices/gnd.sym} 38350 920 0 0 {name=s567 lab=0}
N 35360 950 35360 970 {lab=0}
C {devices/gnd.sym} 35360 970 0 0 {name=s568 lab=0}
N 35360 920 35390 920 {lab=0}
C {devices/gnd.sym} 35390 920 0 0 {name=s569 lab=0}
N 35360 770 35390 770 {lab=0}
C {devices/gnd.sym} 35390 770 0 0 {name=s570 lab=0}
N 35920 950 35920 970 {lab=0}
C {devices/gnd.sym} 35920 970 0 0 {name=s571 lab=0}
N 35920 920 35950 920 {lab=0}
C {devices/gnd.sym} 35950 920 0 0 {name=s572 lab=0}
N 33320 30 33320 10 {lab=VDD}
C {devices/vdd.sym} 33320 10 0 0 {name=s573 lab=VDD}
N 33320 60 33350 60 {lab=VDD}
C {devices/vdd.sym} 33350 60 0 0 {name=s574 lab=VDD}
N 33680 30 33680 10 {lab=VDD}
C {devices/vdd.sym} 33680 10 0 0 {name=s575 lab=VDD}
N 33680 60 33710 60 {lab=VDD}
C {devices/vdd.sym} 33710 60 0 0 {name=s576 lab=VDD}
N 37360 30 37360 10 {lab=VDD}
C {devices/vdd.sym} 37360 10 0 0 {name=s577 lab=VDD}
N 37360 60 37390 60 {lab=VDD}
C {devices/vdd.sym} 37390 60 0 0 {name=s578 lab=VDD}
N 37360 210 37390 210 {lab=VDD}
C {devices/vdd.sym} 37390 210 0 0 {name=s579 lab=VDD}
N 37760 210 37790 210 {lab=VDD}
C {devices/vdd.sym} 37790 210 0 0 {name=s580 lab=VDD}
N 37560 30 37560 10 {lab=VDD}
C {devices/vdd.sym} 37560 10 0 0 {name=s581 lab=VDD}
N 37560 60 37590 60 {lab=VDD}
C {devices/vdd.sym} 37590 60 0 0 {name=s582 lab=VDD}
N 37760 30 37760 10 {lab=VDD}
C {devices/vdd.sym} 37760 10 0 0 {name=s583 lab=VDD}
N 37760 60 37790 60 {lab=VDD}
C {devices/vdd.sym} 37790 60 0 0 {name=s584 lab=VDD}
N 38120 30 38120 10 {lab=VDD}
C {devices/vdd.sym} 38120 10 0 0 {name=s585 lab=VDD}
N 38120 60 38150 60 {lab=VDD}
C {devices/vdd.sym} 38150 60 0 0 {name=s586 lab=VDD}
N 38120 210 38150 210 {lab=VDD}
C {devices/vdd.sym} 38150 210 0 0 {name=s587 lab=VDD}
N 38320 210 38350 210 {lab=VDD}
C {devices/vdd.sym} 38350 210 0 0 {name=s588 lab=VDD}
N 38320 30 38320 10 {lab=VDD}
C {devices/vdd.sym} 38320 10 0 0 {name=s589 lab=VDD}
N 38320 60 38350 60 {lab=VDD}
C {devices/vdd.sym} 38350 60 0 0 {name=s590 lab=VDD}
N 35360 30 35360 10 {lab=VDD}
C {devices/vdd.sym} 35360 10 0 0 {name=s591 lab=VDD}
N 35360 60 35390 60 {lab=VDD}
C {devices/vdd.sym} 35390 60 0 0 {name=s592 lab=VDD}
N 35560 30 35560 10 {lab=VDD}
C {devices/vdd.sym} 35560 10 0 0 {name=s593 lab=VDD}
N 35560 60 35590 60 {lab=VDD}
C {devices/vdd.sym} 35590 60 0 0 {name=s594 lab=VDD}
N 35920 30 35920 10 {lab=VDD}
C {devices/vdd.sym} 35920 10 0 0 {name=s595 lab=VDD}
N 35920 60 35950 60 {lab=VDD}
C {devices/vdd.sym} 35950 60 0 0 {name=s596 lab=VDD}
N 36280 950 36280 970 {lab=0}
C {devices/gnd.sym} 36280 970 0 0 {name=s597 lab=0}
N 36280 920 36310 920 {lab=0}
C {devices/gnd.sym} 36310 920 0 0 {name=s598 lab=0}
N 36280 30 36280 10 {lab=VDD}
C {devices/vdd.sym} 36280 10 0 0 {name=s599 lab=VDD}
N 36280 60 36310 60 {lab=VDD}
C {devices/vdd.sym} 36310 60 0 0 {name=s600 lab=VDD}
N 36640 950 36640 970 {lab=0}
C {devices/gnd.sym} 36640 970 0 0 {name=s601 lab=0}
N 36640 920 36670 920 {lab=0}
C {devices/gnd.sym} 36670 920 0 0 {name=s602 lab=0}
N 37000 950 37000 970 {lab=0}
C {devices/gnd.sym} 37000 970 0 0 {name=s603 lab=0}
N 37000 920 37030 920 {lab=0}
C {devices/gnd.sym} 37030 920 0 0 {name=s604 lab=0}
N 40680 950 40680 970 {lab=0}
C {devices/gnd.sym} 40680 970 0 0 {name=s605 lab=0}
N 40680 920 40710 920 {lab=0}
C {devices/gnd.sym} 40710 920 0 0 {name=s606 lab=0}
N 40680 770 40710 770 {lab=0}
C {devices/gnd.sym} 40710 770 0 0 {name=s607 lab=0}
N 40880 620 40910 620 {lab=0}
C {devices/gnd.sym} 40910 620 0 0 {name=s608 lab=0}
N 40880 770 40910 770 {lab=0}
C {devices/gnd.sym} 40910 770 0 0 {name=s609 lab=0}
N 40880 950 40880 970 {lab=0}
C {devices/gnd.sym} 40880 970 0 0 {name=s610 lab=0}
N 40880 920 40910 920 {lab=0}
C {devices/gnd.sym} 40910 920 0 0 {name=s611 lab=0}
N 41440 950 41440 970 {lab=0}
C {devices/gnd.sym} 41440 970 0 0 {name=s612 lab=0}
N 41440 920 41470 920 {lab=0}
C {devices/gnd.sym} 41470 920 0 0 {name=s613 lab=0}
N 41440 770 41470 770 {lab=0}
C {devices/gnd.sym} 41470 770 0 0 {name=s614 lab=0}
N 41640 770 41670 770 {lab=0}
C {devices/gnd.sym} 41670 770 0 0 {name=s615 lab=0}
N 41640 950 41640 970 {lab=0}
C {devices/gnd.sym} 41640 970 0 0 {name=s616 lab=0}
N 41640 920 41670 920 {lab=0}
C {devices/gnd.sym} 41670 920 0 0 {name=s617 lab=0}
N 38680 950 38680 970 {lab=0}
C {devices/gnd.sym} 38680 970 0 0 {name=s618 lab=0}
N 38680 920 38710 920 {lab=0}
C {devices/gnd.sym} 38710 920 0 0 {name=s619 lab=0}
N 38680 770 38710 770 {lab=0}
C {devices/gnd.sym} 38710 770 0 0 {name=s620 lab=0}
N 39240 950 39240 970 {lab=0}
C {devices/gnd.sym} 39240 970 0 0 {name=s621 lab=0}
N 39240 920 39270 920 {lab=0}
C {devices/gnd.sym} 39270 920 0 0 {name=s622 lab=0}
N 36640 30 36640 10 {lab=VDD}
C {devices/vdd.sym} 36640 10 0 0 {name=s623 lab=VDD}
N 36640 60 36670 60 {lab=VDD}
C {devices/vdd.sym} 36670 60 0 0 {name=s624 lab=VDD}
N 37000 30 37000 10 {lab=VDD}
C {devices/vdd.sym} 37000 10 0 0 {name=s625 lab=VDD}
N 37000 60 37030 60 {lab=VDD}
C {devices/vdd.sym} 37030 60 0 0 {name=s626 lab=VDD}
N 40680 30 40680 10 {lab=VDD}
C {devices/vdd.sym} 40680 10 0 0 {name=s627 lab=VDD}
N 40680 60 40710 60 {lab=VDD}
C {devices/vdd.sym} 40710 60 0 0 {name=s628 lab=VDD}
N 40680 210 40710 210 {lab=VDD}
C {devices/vdd.sym} 40710 210 0 0 {name=s629 lab=VDD}
N 41080 210 41110 210 {lab=VDD}
C {devices/vdd.sym} 41110 210 0 0 {name=s630 lab=VDD}
N 40880 30 40880 10 {lab=VDD}
C {devices/vdd.sym} 40880 10 0 0 {name=s631 lab=VDD}
N 40880 60 40910 60 {lab=VDD}
C {devices/vdd.sym} 40910 60 0 0 {name=s632 lab=VDD}
N 41080 30 41080 10 {lab=VDD}
C {devices/vdd.sym} 41080 10 0 0 {name=s633 lab=VDD}
N 41080 60 41110 60 {lab=VDD}
C {devices/vdd.sym} 41110 60 0 0 {name=s634 lab=VDD}
N 41440 30 41440 10 {lab=VDD}
C {devices/vdd.sym} 41440 10 0 0 {name=s635 lab=VDD}
N 41440 60 41470 60 {lab=VDD}
C {devices/vdd.sym} 41470 60 0 0 {name=s636 lab=VDD}
N 41440 210 41470 210 {lab=VDD}
C {devices/vdd.sym} 41470 210 0 0 {name=s637 lab=VDD}
N 41640 210 41670 210 {lab=VDD}
C {devices/vdd.sym} 41670 210 0 0 {name=s638 lab=VDD}
N 41640 30 41640 10 {lab=VDD}
C {devices/vdd.sym} 41640 10 0 0 {name=s639 lab=VDD}
N 41640 60 41670 60 {lab=VDD}
C {devices/vdd.sym} 41670 60 0 0 {name=s640 lab=VDD}
N 38680 30 38680 10 {lab=VDD}
C {devices/vdd.sym} 38680 10 0 0 {name=s641 lab=VDD}
N 38680 60 38710 60 {lab=VDD}
C {devices/vdd.sym} 38710 60 0 0 {name=s642 lab=VDD}
N 38880 30 38880 10 {lab=VDD}
C {devices/vdd.sym} 38880 10 0 0 {name=s643 lab=VDD}
N 38880 60 38910 60 {lab=VDD}
C {devices/vdd.sym} 38910 60 0 0 {name=s644 lab=VDD}
N 39240 30 39240 10 {lab=VDD}
C {devices/vdd.sym} 39240 10 0 0 {name=s645 lab=VDD}
N 39240 60 39270 60 {lab=VDD}
C {devices/vdd.sym} 39270 60 0 0 {name=s646 lab=VDD}
N 39600 950 39600 970 {lab=0}
C {devices/gnd.sym} 39600 970 0 0 {name=s647 lab=0}
N 39600 920 39630 920 {lab=0}
C {devices/gnd.sym} 39630 920 0 0 {name=s648 lab=0}
N 39600 30 39600 10 {lab=VDD}
C {devices/vdd.sym} 39600 10 0 0 {name=s649 lab=VDD}
N 39600 60 39630 60 {lab=VDD}
C {devices/vdd.sym} 39630 60 0 0 {name=s650 lab=VDD}
N 39960 950 39960 970 {lab=0}
C {devices/gnd.sym} 39960 970 0 0 {name=s651 lab=0}
N 39960 920 39990 920 {lab=0}
C {devices/gnd.sym} 39990 920 0 0 {name=s652 lab=0}
N 40320 950 40320 970 {lab=0}
C {devices/gnd.sym} 40320 970 0 0 {name=s653 lab=0}
N 40320 920 40350 920 {lab=0}
C {devices/gnd.sym} 40350 920 0 0 {name=s654 lab=0}
N 44000 950 44000 970 {lab=0}
C {devices/gnd.sym} 44000 970 0 0 {name=s655 lab=0}
N 44000 920 44030 920 {lab=0}
C {devices/gnd.sym} 44030 920 0 0 {name=s656 lab=0}
N 44000 770 44030 770 {lab=0}
C {devices/gnd.sym} 44030 770 0 0 {name=s657 lab=0}
N 44200 620 44230 620 {lab=0}
C {devices/gnd.sym} 44230 620 0 0 {name=s658 lab=0}
N 44200 770 44230 770 {lab=0}
C {devices/gnd.sym} 44230 770 0 0 {name=s659 lab=0}
N 44200 950 44200 970 {lab=0}
C {devices/gnd.sym} 44200 970 0 0 {name=s660 lab=0}
N 44200 920 44230 920 {lab=0}
C {devices/gnd.sym} 44230 920 0 0 {name=s661 lab=0}
N 44760 950 44760 970 {lab=0}
C {devices/gnd.sym} 44760 970 0 0 {name=s662 lab=0}
N 44760 920 44790 920 {lab=0}
C {devices/gnd.sym} 44790 920 0 0 {name=s663 lab=0}
N 44760 770 44790 770 {lab=0}
C {devices/gnd.sym} 44790 770 0 0 {name=s664 lab=0}
N 44960 770 44990 770 {lab=0}
C {devices/gnd.sym} 44990 770 0 0 {name=s665 lab=0}
N 44960 950 44960 970 {lab=0}
C {devices/gnd.sym} 44960 970 0 0 {name=s666 lab=0}
N 44960 920 44990 920 {lab=0}
C {devices/gnd.sym} 44990 920 0 0 {name=s667 lab=0}
N 42000 950 42000 970 {lab=0}
C {devices/gnd.sym} 42000 970 0 0 {name=s668 lab=0}
N 42000 920 42030 920 {lab=0}
C {devices/gnd.sym} 42030 920 0 0 {name=s669 lab=0}
N 42000 770 42030 770 {lab=0}
C {devices/gnd.sym} 42030 770 0 0 {name=s670 lab=0}
N 42560 950 42560 970 {lab=0}
C {devices/gnd.sym} 42560 970 0 0 {name=s671 lab=0}
N 42560 920 42590 920 {lab=0}
C {devices/gnd.sym} 42590 920 0 0 {name=s672 lab=0}
N 39960 30 39960 10 {lab=VDD}
C {devices/vdd.sym} 39960 10 0 0 {name=s673 lab=VDD}
N 39960 60 39990 60 {lab=VDD}
C {devices/vdd.sym} 39990 60 0 0 {name=s674 lab=VDD}
N 40320 30 40320 10 {lab=VDD}
C {devices/vdd.sym} 40320 10 0 0 {name=s675 lab=VDD}
N 40320 60 40350 60 {lab=VDD}
C {devices/vdd.sym} 40350 60 0 0 {name=s676 lab=VDD}
N 44000 30 44000 10 {lab=VDD}
C {devices/vdd.sym} 44000 10 0 0 {name=s677 lab=VDD}
N 44000 60 44030 60 {lab=VDD}
C {devices/vdd.sym} 44030 60 0 0 {name=s678 lab=VDD}
N 44000 210 44030 210 {lab=VDD}
C {devices/vdd.sym} 44030 210 0 0 {name=s679 lab=VDD}
N 44400 210 44430 210 {lab=VDD}
C {devices/vdd.sym} 44430 210 0 0 {name=s680 lab=VDD}
N 44200 30 44200 10 {lab=VDD}
C {devices/vdd.sym} 44200 10 0 0 {name=s681 lab=VDD}
N 44200 60 44230 60 {lab=VDD}
C {devices/vdd.sym} 44230 60 0 0 {name=s682 lab=VDD}
N 44400 30 44400 10 {lab=VDD}
C {devices/vdd.sym} 44400 10 0 0 {name=s683 lab=VDD}
N 44400 60 44430 60 {lab=VDD}
C {devices/vdd.sym} 44430 60 0 0 {name=s684 lab=VDD}
N 44760 30 44760 10 {lab=VDD}
C {devices/vdd.sym} 44760 10 0 0 {name=s685 lab=VDD}
N 44760 60 44790 60 {lab=VDD}
C {devices/vdd.sym} 44790 60 0 0 {name=s686 lab=VDD}
N 44760 210 44790 210 {lab=VDD}
C {devices/vdd.sym} 44790 210 0 0 {name=s687 lab=VDD}
N 44960 210 44990 210 {lab=VDD}
C {devices/vdd.sym} 44990 210 0 0 {name=s688 lab=VDD}
N 44960 30 44960 10 {lab=VDD}
C {devices/vdd.sym} 44960 10 0 0 {name=s689 lab=VDD}
N 44960 60 44990 60 {lab=VDD}
C {devices/vdd.sym} 44990 60 0 0 {name=s690 lab=VDD}
N 42000 30 42000 10 {lab=VDD}
C {devices/vdd.sym} 42000 10 0 0 {name=s691 lab=VDD}
N 42000 60 42030 60 {lab=VDD}
C {devices/vdd.sym} 42030 60 0 0 {name=s692 lab=VDD}
N 42200 30 42200 10 {lab=VDD}
C {devices/vdd.sym} 42200 10 0 0 {name=s693 lab=VDD}
N 42200 60 42230 60 {lab=VDD}
C {devices/vdd.sym} 42230 60 0 0 {name=s694 lab=VDD}
N 42560 30 42560 10 {lab=VDD}
C {devices/vdd.sym} 42560 10 0 0 {name=s695 lab=VDD}
N 42560 60 42590 60 {lab=VDD}
C {devices/vdd.sym} 42590 60 0 0 {name=s696 lab=VDD}
N 42920 950 42920 970 {lab=0}
C {devices/gnd.sym} 42920 970 0 0 {name=s697 lab=0}
N 42920 920 42950 920 {lab=0}
C {devices/gnd.sym} 42950 920 0 0 {name=s698 lab=0}
N 42920 30 42920 10 {lab=VDD}
C {devices/vdd.sym} 42920 10 0 0 {name=s699 lab=VDD}
N 42920 60 42950 60 {lab=VDD}
C {devices/vdd.sym} 42950 60 0 0 {name=s700 lab=VDD}
N 43280 950 43280 970 {lab=0}
C {devices/gnd.sym} 43280 970 0 0 {name=s701 lab=0}
N 43280 920 43310 920 {lab=0}
C {devices/gnd.sym} 43310 920 0 0 {name=s702 lab=0}
N 43640 950 43640 970 {lab=0}
C {devices/gnd.sym} 43640 970 0 0 {name=s703 lab=0}
N 43640 920 43670 920 {lab=0}
C {devices/gnd.sym} 43670 920 0 0 {name=s704 lab=0}
N 47320 950 47320 970 {lab=0}
C {devices/gnd.sym} 47320 970 0 0 {name=s705 lab=0}
N 47320 920 47350 920 {lab=0}
C {devices/gnd.sym} 47350 920 0 0 {name=s706 lab=0}
N 47320 770 47350 770 {lab=0}
C {devices/gnd.sym} 47350 770 0 0 {name=s707 lab=0}
N 47520 620 47550 620 {lab=0}
C {devices/gnd.sym} 47550 620 0 0 {name=s708 lab=0}
N 47520 770 47550 770 {lab=0}
C {devices/gnd.sym} 47550 770 0 0 {name=s709 lab=0}
N 47520 950 47520 970 {lab=0}
C {devices/gnd.sym} 47520 970 0 0 {name=s710 lab=0}
N 47520 920 47550 920 {lab=0}
C {devices/gnd.sym} 47550 920 0 0 {name=s711 lab=0}
N 48080 950 48080 970 {lab=0}
C {devices/gnd.sym} 48080 970 0 0 {name=s712 lab=0}
N 48080 920 48110 920 {lab=0}
C {devices/gnd.sym} 48110 920 0 0 {name=s713 lab=0}
N 48080 770 48110 770 {lab=0}
C {devices/gnd.sym} 48110 770 0 0 {name=s714 lab=0}
N 48280 770 48310 770 {lab=0}
C {devices/gnd.sym} 48310 770 0 0 {name=s715 lab=0}
N 48280 950 48280 970 {lab=0}
C {devices/gnd.sym} 48280 970 0 0 {name=s716 lab=0}
N 48280 920 48310 920 {lab=0}
C {devices/gnd.sym} 48310 920 0 0 {name=s717 lab=0}
N 45320 950 45320 970 {lab=0}
C {devices/gnd.sym} 45320 970 0 0 {name=s718 lab=0}
N 45320 920 45350 920 {lab=0}
C {devices/gnd.sym} 45350 920 0 0 {name=s719 lab=0}
N 45320 770 45350 770 {lab=0}
C {devices/gnd.sym} 45350 770 0 0 {name=s720 lab=0}
N 45880 950 45880 970 {lab=0}
C {devices/gnd.sym} 45880 970 0 0 {name=s721 lab=0}
N 45880 920 45910 920 {lab=0}
C {devices/gnd.sym} 45910 920 0 0 {name=s722 lab=0}
N 43280 30 43280 10 {lab=VDD}
C {devices/vdd.sym} 43280 10 0 0 {name=s723 lab=VDD}
N 43280 60 43310 60 {lab=VDD}
C {devices/vdd.sym} 43310 60 0 0 {name=s724 lab=VDD}
N 43640 30 43640 10 {lab=VDD}
C {devices/vdd.sym} 43640 10 0 0 {name=s725 lab=VDD}
N 43640 60 43670 60 {lab=VDD}
C {devices/vdd.sym} 43670 60 0 0 {name=s726 lab=VDD}
N 47320 30 47320 10 {lab=VDD}
C {devices/vdd.sym} 47320 10 0 0 {name=s727 lab=VDD}
N 47320 60 47350 60 {lab=VDD}
C {devices/vdd.sym} 47350 60 0 0 {name=s728 lab=VDD}
N 47320 210 47350 210 {lab=VDD}
C {devices/vdd.sym} 47350 210 0 0 {name=s729 lab=VDD}
N 47720 210 47750 210 {lab=VDD}
C {devices/vdd.sym} 47750 210 0 0 {name=s730 lab=VDD}
N 47520 30 47520 10 {lab=VDD}
C {devices/vdd.sym} 47520 10 0 0 {name=s731 lab=VDD}
N 47520 60 47550 60 {lab=VDD}
C {devices/vdd.sym} 47550 60 0 0 {name=s732 lab=VDD}
N 47720 30 47720 10 {lab=VDD}
C {devices/vdd.sym} 47720 10 0 0 {name=s733 lab=VDD}
N 47720 60 47750 60 {lab=VDD}
C {devices/vdd.sym} 47750 60 0 0 {name=s734 lab=VDD}
N 48080 30 48080 10 {lab=VDD}
C {devices/vdd.sym} 48080 10 0 0 {name=s735 lab=VDD}
N 48080 60 48110 60 {lab=VDD}
C {devices/vdd.sym} 48110 60 0 0 {name=s736 lab=VDD}
N 48080 210 48110 210 {lab=VDD}
C {devices/vdd.sym} 48110 210 0 0 {name=s737 lab=VDD}
N 48280 210 48310 210 {lab=VDD}
C {devices/vdd.sym} 48310 210 0 0 {name=s738 lab=VDD}
N 48280 30 48280 10 {lab=VDD}
C {devices/vdd.sym} 48280 10 0 0 {name=s739 lab=VDD}
N 48280 60 48310 60 {lab=VDD}
C {devices/vdd.sym} 48310 60 0 0 {name=s740 lab=VDD}
N 45320 30 45320 10 {lab=VDD}
C {devices/vdd.sym} 45320 10 0 0 {name=s741 lab=VDD}
N 45320 60 45350 60 {lab=VDD}
C {devices/vdd.sym} 45350 60 0 0 {name=s742 lab=VDD}
N 45520 30 45520 10 {lab=VDD}
C {devices/vdd.sym} 45520 10 0 0 {name=s743 lab=VDD}
N 45520 60 45550 60 {lab=VDD}
C {devices/vdd.sym} 45550 60 0 0 {name=s744 lab=VDD}
N 45880 30 45880 10 {lab=VDD}
C {devices/vdd.sym} 45880 10 0 0 {name=s745 lab=VDD}
N 45880 60 45910 60 {lab=VDD}
C {devices/vdd.sym} 45910 60 0 0 {name=s746 lab=VDD}
N 46240 950 46240 970 {lab=0}
C {devices/gnd.sym} 46240 970 0 0 {name=s747 lab=0}
N 46240 920 46270 920 {lab=0}
C {devices/gnd.sym} 46270 920 0 0 {name=s748 lab=0}
N 46240 30 46240 10 {lab=VDD}
C {devices/vdd.sym} 46240 10 0 0 {name=s749 lab=VDD}
N 46240 60 46270 60 {lab=VDD}
C {devices/vdd.sym} 46270 60 0 0 {name=s750 lab=VDD}
N 46600 950 46600 970 {lab=0}
C {devices/gnd.sym} 46600 970 0 0 {name=s751 lab=0}
N 46600 920 46630 920 {lab=0}
C {devices/gnd.sym} 46630 920 0 0 {name=s752 lab=0}
N 46960 950 46960 970 {lab=0}
C {devices/gnd.sym} 46960 970 0 0 {name=s753 lab=0}
N 46960 920 46990 920 {lab=0}
C {devices/gnd.sym} 46990 920 0 0 {name=s754 lab=0}
N 50640 950 50640 970 {lab=0}
C {devices/gnd.sym} 50640 970 0 0 {name=s755 lab=0}
N 50640 920 50670 920 {lab=0}
C {devices/gnd.sym} 50670 920 0 0 {name=s756 lab=0}
N 50640 770 50670 770 {lab=0}
C {devices/gnd.sym} 50670 770 0 0 {name=s757 lab=0}
N 50840 620 50870 620 {lab=0}
C {devices/gnd.sym} 50870 620 0 0 {name=s758 lab=0}
N 50840 770 50870 770 {lab=0}
C {devices/gnd.sym} 50870 770 0 0 {name=s759 lab=0}
N 50840 950 50840 970 {lab=0}
C {devices/gnd.sym} 50840 970 0 0 {name=s760 lab=0}
N 50840 920 50870 920 {lab=0}
C {devices/gnd.sym} 50870 920 0 0 {name=s761 lab=0}
N 51400 950 51400 970 {lab=0}
C {devices/gnd.sym} 51400 970 0 0 {name=s762 lab=0}
N 51400 920 51430 920 {lab=0}
C {devices/gnd.sym} 51430 920 0 0 {name=s763 lab=0}
N 51400 770 51430 770 {lab=0}
C {devices/gnd.sym} 51430 770 0 0 {name=s764 lab=0}
N 51600 770 51630 770 {lab=0}
C {devices/gnd.sym} 51630 770 0 0 {name=s765 lab=0}
N 51600 950 51600 970 {lab=0}
C {devices/gnd.sym} 51600 970 0 0 {name=s766 lab=0}
N 51600 920 51630 920 {lab=0}
C {devices/gnd.sym} 51630 920 0 0 {name=s767 lab=0}
N 48640 950 48640 970 {lab=0}
C {devices/gnd.sym} 48640 970 0 0 {name=s768 lab=0}
N 48640 920 48670 920 {lab=0}
C {devices/gnd.sym} 48670 920 0 0 {name=s769 lab=0}
N 48640 770 48670 770 {lab=0}
C {devices/gnd.sym} 48670 770 0 0 {name=s770 lab=0}
N 49200 950 49200 970 {lab=0}
C {devices/gnd.sym} 49200 970 0 0 {name=s771 lab=0}
N 49200 920 49230 920 {lab=0}
C {devices/gnd.sym} 49230 920 0 0 {name=s772 lab=0}
N 46600 30 46600 10 {lab=VDD}
C {devices/vdd.sym} 46600 10 0 0 {name=s773 lab=VDD}
N 46600 60 46630 60 {lab=VDD}
C {devices/vdd.sym} 46630 60 0 0 {name=s774 lab=VDD}
N 46960 30 46960 10 {lab=VDD}
C {devices/vdd.sym} 46960 10 0 0 {name=s775 lab=VDD}
N 46960 60 46990 60 {lab=VDD}
C {devices/vdd.sym} 46990 60 0 0 {name=s776 lab=VDD}
N 50640 30 50640 10 {lab=VDD}
C {devices/vdd.sym} 50640 10 0 0 {name=s777 lab=VDD}
N 50640 60 50670 60 {lab=VDD}
C {devices/vdd.sym} 50670 60 0 0 {name=s778 lab=VDD}
N 50640 210 50670 210 {lab=VDD}
C {devices/vdd.sym} 50670 210 0 0 {name=s779 lab=VDD}
N 51040 210 51070 210 {lab=VDD}
C {devices/vdd.sym} 51070 210 0 0 {name=s780 lab=VDD}
N 50840 30 50840 10 {lab=VDD}
C {devices/vdd.sym} 50840 10 0 0 {name=s781 lab=VDD}
N 50840 60 50870 60 {lab=VDD}
C {devices/vdd.sym} 50870 60 0 0 {name=s782 lab=VDD}
N 51040 30 51040 10 {lab=VDD}
C {devices/vdd.sym} 51040 10 0 0 {name=s783 lab=VDD}
N 51040 60 51070 60 {lab=VDD}
C {devices/vdd.sym} 51070 60 0 0 {name=s784 lab=VDD}
N 51400 30 51400 10 {lab=VDD}
C {devices/vdd.sym} 51400 10 0 0 {name=s785 lab=VDD}
N 51400 60 51430 60 {lab=VDD}
C {devices/vdd.sym} 51430 60 0 0 {name=s786 lab=VDD}
N 51400 210 51430 210 {lab=VDD}
C {devices/vdd.sym} 51430 210 0 0 {name=s787 lab=VDD}
N 51600 210 51630 210 {lab=VDD}
C {devices/vdd.sym} 51630 210 0 0 {name=s788 lab=VDD}
N 51600 30 51600 10 {lab=VDD}
C {devices/vdd.sym} 51600 10 0 0 {name=s789 lab=VDD}
N 51600 60 51630 60 {lab=VDD}
C {devices/vdd.sym} 51630 60 0 0 {name=s790 lab=VDD}
N 48640 30 48640 10 {lab=VDD}
C {devices/vdd.sym} 48640 10 0 0 {name=s791 lab=VDD}
N 48640 60 48670 60 {lab=VDD}
C {devices/vdd.sym} 48670 60 0 0 {name=s792 lab=VDD}
N 48840 30 48840 10 {lab=VDD}
C {devices/vdd.sym} 48840 10 0 0 {name=s793 lab=VDD}
N 48840 60 48870 60 {lab=VDD}
C {devices/vdd.sym} 48870 60 0 0 {name=s794 lab=VDD}
N 49200 30 49200 10 {lab=VDD}
C {devices/vdd.sym} 49200 10 0 0 {name=s795 lab=VDD}
N 49200 60 49230 60 {lab=VDD}
C {devices/vdd.sym} 49230 60 0 0 {name=s796 lab=VDD}
N 49560 950 49560 970 {lab=0}
C {devices/gnd.sym} 49560 970 0 0 {name=s797 lab=0}
N 49560 920 49590 920 {lab=0}
C {devices/gnd.sym} 49590 920 0 0 {name=s798 lab=0}
N 49560 30 49560 10 {lab=VDD}
C {devices/vdd.sym} 49560 10 0 0 {name=s799 lab=VDD}
N 49560 60 49590 60 {lab=VDD}
C {devices/vdd.sym} 49590 60 0 0 {name=s800 lab=VDD}
N 49920 950 49920 970 {lab=0}
C {devices/gnd.sym} 49920 970 0 0 {name=s801 lab=0}
N 49920 920 49950 920 {lab=0}
C {devices/gnd.sym} 49950 920 0 0 {name=s802 lab=0}
N 50280 950 50280 970 {lab=0}
C {devices/gnd.sym} 50280 970 0 0 {name=s803 lab=0}
N 50280 920 50310 920 {lab=0}
C {devices/gnd.sym} 50310 920 0 0 {name=s804 lab=0}
N 55280 950 55280 970 {lab=0}
C {devices/gnd.sym} 55280 970 0 0 {name=s805 lab=0}
N 55280 920 55310 920 {lab=0}
C {devices/gnd.sym} 55310 920 0 0 {name=s806 lab=0}
N 55280 770 55310 770 {lab=0}
C {devices/gnd.sym} 55310 770 0 0 {name=s807 lab=0}
N 55480 620 55510 620 {lab=0}
C {devices/gnd.sym} 55510 620 0 0 {name=s808 lab=0}
N 55480 770 55510 770 {lab=0}
C {devices/gnd.sym} 55510 770 0 0 {name=s809 lab=0}
N 55480 950 55480 970 {lab=0}
C {devices/gnd.sym} 55480 970 0 0 {name=s810 lab=0}
N 55480 920 55510 920 {lab=0}
C {devices/gnd.sym} 55510 920 0 0 {name=s811 lab=0}
N 56040 950 56040 970 {lab=0}
C {devices/gnd.sym} 56040 970 0 0 {name=s812 lab=0}
N 56040 920 56070 920 {lab=0}
C {devices/gnd.sym} 56070 920 0 0 {name=s813 lab=0}
N 56040 770 56070 770 {lab=0}
C {devices/gnd.sym} 56070 770 0 0 {name=s814 lab=0}
N 56240 770 56270 770 {lab=0}
C {devices/gnd.sym} 56270 770 0 0 {name=s815 lab=0}
N 56240 950 56240 970 {lab=0}
C {devices/gnd.sym} 56240 970 0 0 {name=s816 lab=0}
N 56240 920 56270 920 {lab=0}
C {devices/gnd.sym} 56270 920 0 0 {name=s817 lab=0}
N 51960 950 51960 970 {lab=0}
C {devices/gnd.sym} 51960 970 0 0 {name=s818 lab=0}
N 51960 920 51990 920 {lab=0}
C {devices/gnd.sym} 51990 920 0 0 {name=s819 lab=0}
N 51960 770 51990 770 {lab=0}
C {devices/gnd.sym} 51990 770 0 0 {name=s820 lab=0}
N 52520 950 52520 970 {lab=0}
C {devices/gnd.sym} 52520 970 0 0 {name=s821 lab=0}
N 52520 920 52550 920 {lab=0}
C {devices/gnd.sym} 52550 920 0 0 {name=s822 lab=0}
N 49920 30 49920 10 {lab=VDD}
C {devices/vdd.sym} 49920 10 0 0 {name=s823 lab=VDD}
N 49920 60 49950 60 {lab=VDD}
C {devices/vdd.sym} 49950 60 0 0 {name=s824 lab=VDD}
N 50280 30 50280 10 {lab=VDD}
C {devices/vdd.sym} 50280 10 0 0 {name=s825 lab=VDD}
N 50280 60 50310 60 {lab=VDD}
C {devices/vdd.sym} 50310 60 0 0 {name=s826 lab=VDD}
N 55280 30 55280 10 {lab=VDD}
C {devices/vdd.sym} 55280 10 0 0 {name=s827 lab=VDD}
N 55280 60 55310 60 {lab=VDD}
C {devices/vdd.sym} 55310 60 0 0 {name=s828 lab=VDD}
N 55280 210 55310 210 {lab=VDD}
C {devices/vdd.sym} 55310 210 0 0 {name=s829 lab=VDD}
N 55680 210 55710 210 {lab=VDD}
C {devices/vdd.sym} 55710 210 0 0 {name=s830 lab=VDD}
N 55480 30 55480 10 {lab=VDD}
C {devices/vdd.sym} 55480 10 0 0 {name=s831 lab=VDD}
N 55480 60 55510 60 {lab=VDD}
C {devices/vdd.sym} 55510 60 0 0 {name=s832 lab=VDD}
N 55680 30 55680 10 {lab=VDD}
C {devices/vdd.sym} 55680 10 0 0 {name=s833 lab=VDD}
N 55680 60 55710 60 {lab=VDD}
C {devices/vdd.sym} 55710 60 0 0 {name=s834 lab=VDD}
N 56040 30 56040 10 {lab=VDD}
C {devices/vdd.sym} 56040 10 0 0 {name=s835 lab=VDD}
N 56040 60 56070 60 {lab=VDD}
C {devices/vdd.sym} 56070 60 0 0 {name=s836 lab=VDD}
N 56040 210 56070 210 {lab=VDD}
C {devices/vdd.sym} 56070 210 0 0 {name=s837 lab=VDD}
N 56240 210 56270 210 {lab=VDD}
C {devices/vdd.sym} 56270 210 0 0 {name=s838 lab=VDD}
N 56240 30 56240 10 {lab=VDD}
C {devices/vdd.sym} 56240 10 0 0 {name=s839 lab=VDD}
N 56240 60 56270 60 {lab=VDD}
C {devices/vdd.sym} 56270 60 0 0 {name=s840 lab=VDD}
N 51960 30 51960 10 {lab=VDD}
C {devices/vdd.sym} 51960 10 0 0 {name=s841 lab=VDD}
N 51960 60 51990 60 {lab=VDD}
C {devices/vdd.sym} 51990 60 0 0 {name=s842 lab=VDD}
N 52160 30 52160 10 {lab=VDD}
C {devices/vdd.sym} 52160 10 0 0 {name=s843 lab=VDD}
N 52160 60 52190 60 {lab=VDD}
C {devices/vdd.sym} 52190 60 0 0 {name=s844 lab=VDD}
N 52520 30 52520 10 {lab=VDD}
C {devices/vdd.sym} 52520 10 0 0 {name=s845 lab=VDD}
N 52520 60 52550 60 {lab=VDD}
C {devices/vdd.sym} 52550 60 0 0 {name=s846 lab=VDD}
N 53600 950 53600 970 {lab=0}
C {devices/gnd.sym} 53600 970 0 0 {name=s847 lab=0}
N 53600 920 53630 920 {lab=0}
C {devices/gnd.sym} 53630 920 0 0 {name=s848 lab=0}
N 53600 30 53600 10 {lab=VDD}
C {devices/vdd.sym} 53600 10 0 0 {name=s849 lab=VDD}
N 53600 60 53630 60 {lab=VDD}
C {devices/vdd.sym} 53630 60 0 0 {name=s850 lab=VDD}
N 3040 920 3030 920 {lab=run}
N 3030 920 3030 880 {lab=run}
N 3030 880 3120 880 {lab=run}
N 3030 880 830 880 {lab=run}
N 3120 880 3120 60 {lab=run}
N 3120 880 3880 880 {lab=run}
N 3120 60 3240 60 {lab=run}
N 3880 880 3880 920 {lab=run}
N 3880 920 4150 920 {lab=run}
N 4150 920 4150 880 {lab=run}
N 4150 920 4160 920 {lab=run}
N 4150 880 4150 60 {lab=run}
N 4150 880 5880 880 {lab=run}
N 4150 60 4160 60 {lab=run}
N 830 880 830 920 {lab=run}
N 830 880 830 530 {lab=run}
N 830 920 840 920 {lab=run}
N 830 530 -60 530 {lab=run}
N 830 530 830 60 {lab=run}
N 830 60 840 60 {lab=run}
N 5880 880 5880 920 {lab=run}
N 5880 920 6150 920 {lab=run}
N 6150 920 6160 920 {lab=run}
N 6150 920 6150 880 {lab=run}
N 6150 880 8240 880 {lab=run}
N 6150 880 6150 60 {lab=run}
N 6150 60 6160 60 {lab=run}
N 8240 880 8240 920 {lab=run}
N 8240 920 8350 920 {lab=run}
N 8350 920 8360 920 {lab=run}
N 8350 920 8350 880 {lab=run}
N 8350 880 8440 880 {lab=run}
N 8440 880 8440 60 {lab=run}
N 8440 880 9200 880 {lab=run}
N 8440 60 8560 60 {lab=run}
N 9200 880 9200 920 {lab=run}
N 9200 920 9470 920 {lab=run}
N 9470 920 9480 920 {lab=run}
N 9470 920 9470 880 {lab=run}
N 9470 880 9470 60 {lab=run}
N 9470 880 11560 880 {lab=run}
N 9470 60 9480 60 {lab=run}
N 11560 880 11560 920 {lab=run}
N 11560 920 11670 920 {lab=run}
N 11670 920 11670 880 {lab=run}
N 11670 920 11680 920 {lab=run}
N 11670 880 11760 880 {lab=run}
N 11760 880 12520 880 {lab=run}
N 11760 880 11760 60 {lab=run}
N 11760 60 11880 60 {lab=run}
N 12520 880 12520 920 {lab=run}
N 12520 920 12790 920 {lab=run}
N 12790 920 12790 880 {lab=run}
N 12790 920 12800 920 {lab=run}
N 12790 880 12790 60 {lab=run}
N 12790 880 14880 880 {lab=run}
N 12790 60 12800 60 {lab=run}
N 14880 880 14880 920 {lab=run}
N 14880 920 14990 920 {lab=run}
N 14990 920 14990 880 {lab=run}
N 14990 920 15000 920 {lab=run}
N 14990 880 15080 880 {lab=run}
N 15080 880 15840 880 {lab=run}
N 15080 880 15080 60 {lab=run}
N 15080 60 15200 60 {lab=run}
N 15840 880 15840 920 {lab=run}
N 15840 920 16110 920 {lab=run}
N 16110 920 16120 920 {lab=run}
N 16110 920 16110 880 {lab=run}
N 16110 880 18200 880 {lab=run}
N 16110 880 16110 60 {lab=run}
N 16110 60 16120 60 {lab=run}
N 18200 880 18200 920 {lab=run}
N 18200 920 18310 920 {lab=run}
N 18310 920 18320 920 {lab=run}
N 18310 920 18310 880 {lab=run}
N 18310 880 18400 880 {lab=run}
N 18400 880 18400 60 {lab=run}
N 18400 880 19160 880 {lab=run}
N 18400 60 18520 60 {lab=run}
N 19160 880 19160 920 {lab=run}
N 19160 920 19430 920 {lab=run}
N 19430 920 19440 920 {lab=run}
N 19430 920 19430 880 {lab=run}
N 19430 880 19430 60 {lab=run}
N 19430 880 21520 880 {lab=run}
N 19430 60 19440 60 {lab=run}
N 21520 880 21520 920 {lab=run}
N 21520 920 21630 920 {lab=run}
N 21630 920 21640 920 {lab=run}
N 21630 920 21630 880 {lab=run}
N 21630 880 21720 880 {lab=run}
N 21720 880 22480 880 {lab=run}
N 21720 880 21720 60 {lab=run}
N 21720 60 21840 60 {lab=run}
N 22480 880 22480 920 {lab=run}
N 22480 920 22750 920 {lab=run}
N 22750 920 22750 880 {lab=run}
N 22750 920 22760 920 {lab=run}
N 22750 880 22750 60 {lab=run}
N 22750 880 24120 880 {lab=run}
N 22750 60 22760 60 {lab=run}
N 24120 880 24120 920 {lab=run}
N 24120 920 24230 920 {lab=run}
N 24230 920 24240 920 {lab=run}
N 24230 920 24230 880 {lab=run}
N 24230 880 24320 880 {lab=run}
N 24320 880 24320 60 {lab=run}
N 24320 880 25080 880 {lab=run}
N 24320 60 24440 60 {lab=run}
N 25080 880 25080 920 {lab=run}
N 25080 920 25350 920 {lab=run}
N 25350 920 25360 920 {lab=run}
N 25350 920 25350 880 {lab=run}
N 25350 880 25350 60 {lab=run}
N 25350 880 27440 880 {lab=run}
N 25350 60 25360 60 {lab=run}
N 27440 880 27440 920 {lab=run}
N 27440 920 27550 920 {lab=run}
N 27550 920 27560 920 {lab=run}
N 27550 920 27550 880 {lab=run}
N 27550 880 27640 880 {lab=run}
N 27640 880 28400 880 {lab=run}
N 27640 880 27640 60 {lab=run}
N 27640 60 27760 60 {lab=run}
N 28400 880 28400 920 {lab=run}
N 28400 920 28670 920 {lab=run}
N 28670 920 28670 880 {lab=run}
N 28670 920 28680 920 {lab=run}
N 28670 880 28670 60 {lab=run}
N 28670 880 30760 880 {lab=run}
N 28670 60 28680 60 {lab=run}
N 30760 880 30760 920 {lab=run}
N 30760 920 30870 920 {lab=run}
N 30870 920 30870 880 {lab=run}
N 30870 920 30880 920 {lab=run}
N 30870 880 30960 880 {lab=run}
N 30960 880 31720 880 {lab=run}
N 30960 880 30960 60 {lab=run}
N 30960 60 31080 60 {lab=run}
N 31720 880 31720 920 {lab=run}
N 31720 920 31990 920 {lab=run}
N 31990 920 31990 880 {lab=run}
N 31990 920 32000 920 {lab=run}
N 31990 880 34080 880 {lab=run}
N 31990 880 31990 60 {lab=run}
N 31990 60 32000 60 {lab=run}
N 34080 880 34080 920 {lab=run}
N 34080 920 34190 920 {lab=run}
N 34190 920 34190 880 {lab=run}
N 34190 920 34200 920 {lab=run}
N 34190 880 34280 880 {lab=run}
N 34280 880 34280 60 {lab=run}
N 34280 880 35040 880 {lab=run}
N 34280 60 34400 60 {lab=run}
N 35040 880 35040 920 {lab=run}
N 35040 920 35310 920 {lab=run}
N 35310 920 35320 920 {lab=run}
N 35310 920 35310 880 {lab=run}
N 35310 880 37400 880 {lab=run}
N 35310 880 35310 60 {lab=run}
N 35310 60 35320 60 {lab=run}
N 37400 880 37400 920 {lab=run}
N 37400 920 37510 920 {lab=run}
N 37510 920 37520 920 {lab=run}
N 37510 920 37510 880 {lab=run}
N 37510 880 37600 880 {lab=run}
N 37600 880 37600 60 {lab=run}
N 37600 880 38360 880 {lab=run}
N 37600 60 37720 60 {lab=run}
N 38360 880 38360 920 {lab=run}
N 38360 920 38630 920 {lab=run}
N 38630 920 38640 920 {lab=run}
N 38630 920 38630 880 {lab=run}
N 38630 880 38630 60 {lab=run}
N 38630 880 40720 880 {lab=run}
N 38630 60 38640 60 {lab=run}
N 40720 880 40720 920 {lab=run}
N 40720 920 40830 920 {lab=run}
N 40830 920 40840 920 {lab=run}
N 40830 920 40830 880 {lab=run}
N 40830 880 40920 880 {lab=run}
N 40920 880 41680 880 {lab=run}
N 40920 880 40920 60 {lab=run}
N 40920 60 41040 60 {lab=run}
N 41680 880 41680 920 {lab=run}
N 41680 920 41950 920 {lab=run}
N 41950 920 41950 880 {lab=run}
N 41950 920 41960 920 {lab=run}
N 41950 880 44040 880 {lab=run}
N 41950 880 41950 60 {lab=run}
N 41950 60 41960 60 {lab=run}
N 44040 880 44040 920 {lab=run}
N 44040 920 44150 920 {lab=run}
N 44150 920 44150 880 {lab=run}
N 44150 920 44160 920 {lab=run}
N 44150 880 44240 880 {lab=run}
N 44240 880 45000 880 {lab=run}
N 44240 880 44240 60 {lab=run}
N 44240 60 44360 60 {lab=run}
N 45000 880 45000 920 {lab=run}
N 45000 920 45270 920 {lab=run}
N 45270 920 45280 920 {lab=run}
N 45270 920 45270 880 {lab=run}
N 45270 880 47360 880 {lab=run}
N 45270 880 45270 60 {lab=run}
N 45270 60 45280 60 {lab=run}
N 47360 880 47360 920 {lab=run}
N 47360 920 47470 920 {lab=run}
N 47470 920 47480 920 {lab=run}
N 47470 920 47470 880 {lab=run}
N 47470 880 47560 880 {lab=run}
N 47560 880 47560 60 {lab=run}
N 47560 880 48320 880 {lab=run}
N 47560 60 47680 60 {lab=run}
N 48320 880 48320 920 {lab=run}
N 48320 920 48590 920 {lab=run}
N 48590 920 48600 920 {lab=run}
N 48590 920 48590 880 {lab=run}
N 48590 880 48590 60 {lab=run}
N 48590 880 50680 880 {lab=run}
N 48590 60 48600 60 {lab=run}
N 50680 880 50680 920 {lab=run}
N 50680 920 50790 920 {lab=run}
N 50790 920 50800 920 {lab=run}
N 50790 920 50790 880 {lab=run}
N 50790 880 50880 880 {lab=run}
N 50880 880 50880 60 {lab=run}
N 50880 880 51640 880 {lab=run}
N 50880 60 51000 60 {lab=run}
N 51640 880 51640 920 {lab=run}
N 51640 920 51910 920 {lab=run}
N 51910 920 51910 880 {lab=run}
N 51910 920 51920 920 {lab=run}
N 51910 880 54000 880 {lab=run}
N 51910 880 51910 60 {lab=run}
N 51910 60 51920 60 {lab=run}
N 54000 880 54000 920 {lab=run}
N 54000 920 54110 920 {lab=run}
N 54110 920 54110 880 {lab=run}
N 54110 920 54120 920 {lab=run}
N 54110 880 54200 880 {lab=run}
N 54200 880 55320 880 {lab=run}
N 54200 880 54200 60 {lab=run}
N 54200 60 54320 60 {lab=run}
N 55320 880 55320 920 {lab=run}
N 55320 920 55430 920 {lab=run}
N 55430 920 55440 920 {lab=run}
N 55430 920 55430 880 {lab=run}
N 55430 880 55520 880 {lab=run}
N 55520 880 55520 60 {lab=run}
N 55520 60 55640 60 {lab=run}
N 2160 890 2160 90 {lab=n1_ff.ncki}
N 2160 890 2200 890 {lab=n1_ff.ncki}
N 2200 890 2200 920 {lab=n1_ff.ncki}
N 2200 920 2470 920 {lab=n1_ff.ncki}
N 2470 920 2470 980 {lab=n1_ff.ncki}
N 2470 920 2480 920 {lab=n1_ff.ncki}
N 2160 90 2200 90 {lab=n1_ff.ncki}
N 2200 90 2200 60 {lab=n1_ff.ncki}
N 2200 60 2480 60 {lab=n1_ff.ncki}
N 2470 980 25440 980 {lab=n1_ff.ncki}
N 25440 980 25440 620 {lab=n1_ff.ncki}
N 25440 620 27350 620 {lab=n1_ff.ncki}
N 27350 620 27350 210 {lab=n1_ff.ncki}
N 27350 620 27550 620 {lab=n1_ff.ncki}
N 27550 620 27560 620 {lab=n1_ff.ncki}
N 27550 620 27550 660 {lab=n1_ff.ncki}
N 27350 210 27360 210 {lab=n1_ff.ncki}
N 27550 660 27660 660 {lab=n1_ff.ncki}
N 27660 660 27660 770 {lab=n1_ff.ncki}
N 27660 770 28110 770 {lab=n1_ff.ncki}
N 28110 770 28120 770 {lab=n1_ff.ncki}
N 28110 770 28110 730 {lab=n1_ff.ncki}
N 28110 730 28200 730 {lab=n1_ff.ncki}
N 28200 730 28200 210 {lab=n1_ff.ncki}
N 28200 210 28320 210 {lab=n1_ff.ncki}
N 49920 890 49920 660 {lab=n9_ff.ncki}
N 49920 890 49960 890 {lab=n9_ff.ncki}
N 49960 890 49960 920 {lab=n9_ff.ncki}
N 49960 920 50240 920 {lab=n9_ff.ncki}
N 49920 660 49920 90 {lab=n9_ff.ncki}
N 49920 660 54220 660 {lab=n9_ff.ncki}
N 49920 90 49960 90 {lab=n9_ff.ncki}
N 49960 90 49960 60 {lab=n9_ff.ncki}
N 49960 60 50240 60 {lab=n9_ff.ncki}
N 54220 660 54220 620 {lab=n9_ff.ncki}
N 54220 620 55230 620 {lab=n9_ff.ncki}
N 55230 620 55230 210 {lab=n9_ff.ncki}
N 55230 620 55430 620 {lab=n9_ff.ncki}
N 55430 620 55430 660 {lab=n9_ff.ncki}
N 55430 620 55440 620 {lab=n9_ff.ncki}
N 55230 210 55240 210 {lab=n9_ff.ncki}
N 55430 660 55540 660 {lab=n9_ff.ncki}
N 55540 660 55540 770 {lab=n9_ff.ncki}
N 55540 770 55990 770 {lab=n9_ff.ncki}
N 55990 770 56000 770 {lab=n9_ff.ncki}
N 55990 770 55990 730 {lab=n9_ff.ncki}
N 55990 730 56080 730 {lab=n9_ff.ncki}
N 56080 730 56080 210 {lab=n9_ff.ncki}
N 56080 210 56200 210 {lab=n9_ff.ncki}
N 7480 890 7480 660 {lab=n12_ff.ncki}
N 7480 890 7520 890 {lab=n12_ff.ncki}
N 7520 890 7520 920 {lab=n12_ff.ncki}
N 7520 920 7800 920 {lab=n12_ff.ncki}
N 7480 660 8460 660 {lab=n12_ff.ncki}
N 7480 660 7480 90 {lab=n12_ff.ncki}
N 7480 90 7520 90 {lab=n12_ff.ncki}
N 7520 90 7520 60 {lab=n12_ff.ncki}
N 7520 60 7800 60 {lab=n12_ff.ncki}
N 8460 660 8460 620 {lab=n12_ff.ncki}
N 8460 620 11470 620 {lab=n12_ff.ncki}
N 11470 620 11470 210 {lab=n12_ff.ncki}
N 11470 620 11670 620 {lab=n12_ff.ncki}
N 11670 620 11680 620 {lab=n12_ff.ncki}
N 11670 620 11670 660 {lab=n12_ff.ncki}
N 11470 210 11480 210 {lab=n12_ff.ncki}
N 11670 660 11780 660 {lab=n12_ff.ncki}
N 11780 660 11780 770 {lab=n12_ff.ncki}
N 11780 770 12230 770 {lab=n12_ff.ncki}
N 12230 770 12240 770 {lab=n12_ff.ncki}
N 12230 770 12230 730 {lab=n12_ff.ncki}
N 12230 730 12320 730 {lab=n12_ff.ncki}
N 12320 730 12320 210 {lab=n12_ff.ncki}
N 12320 210 12440 210 {lab=n12_ff.ncki}
N 10800 890 10800 90 {lab=n13_ff.ncki}
N 10800 890 10840 890 {lab=n13_ff.ncki}
N 10840 890 10840 920 {lab=n13_ff.ncki}
N 10840 920 11110 920 {lab=n13_ff.ncki}
N 11110 920 11110 860 {lab=n13_ff.ncki}
N 11110 920 11120 920 {lab=n13_ff.ncki}
N 10800 90 10840 90 {lab=n13_ff.ncki}
N 10840 90 10840 60 {lab=n13_ff.ncki}
N 10840 60 11120 60 {lab=n13_ff.ncki}
N 11110 860 12340 860 {lab=n13_ff.ncki}
N 12340 860 12340 620 {lab=n13_ff.ncki}
N 12340 620 14790 620 {lab=n13_ff.ncki}
N 14790 620 14790 210 {lab=n13_ff.ncki}
N 14790 620 14990 620 {lab=n13_ff.ncki}
N 14990 620 14990 660 {lab=n13_ff.ncki}
N 14990 620 15000 620 {lab=n13_ff.ncki}
N 14790 210 14800 210 {lab=n13_ff.ncki}
N 14990 660 15100 660 {lab=n13_ff.ncki}
N 15100 660 15100 770 {lab=n13_ff.ncki}
N 15100 770 15550 770 {lab=n13_ff.ncki}
N 15550 770 15550 730 {lab=n13_ff.ncki}
N 15550 770 15560 770 {lab=n13_ff.ncki}
N 15550 730 15640 730 {lab=n13_ff.ncki}
N 15640 730 15640 210 {lab=n13_ff.ncki}
N 15640 210 15760 210 {lab=n13_ff.ncki}
N 14120 890 14160 890 {lab=n14_ff.ncki}
N 14120 890 14120 90 {lab=n14_ff.ncki}
N 14160 890 14160 920 {lab=n14_ff.ncki}
N 14160 920 14430 920 {lab=n14_ff.ncki}
N 14430 920 14440 920 {lab=n14_ff.ncki}
N 14430 920 14430 860 {lab=n14_ff.ncki}
N 14120 90 14160 90 {lab=n14_ff.ncki}
N 14160 90 14160 60 {lab=n14_ff.ncki}
N 14160 60 14440 60 {lab=n14_ff.ncki}
N 14430 860 15660 860 {lab=n14_ff.ncki}
N 15660 860 15660 620 {lab=n14_ff.ncki}
N 15660 620 18110 620 {lab=n14_ff.ncki}
N 18110 620 18310 620 {lab=n14_ff.ncki}
N 18110 620 18110 210 {lab=n14_ff.ncki}
N 18310 620 18310 660 {lab=n14_ff.ncki}
N 18310 620 18320 620 {lab=n14_ff.ncki}
N 18110 210 18120 210 {lab=n14_ff.ncki}
N 18310 660 18420 660 {lab=n14_ff.ncki}
N 18420 660 18420 770 {lab=n14_ff.ncki}
N 18420 770 18870 770 {lab=n14_ff.ncki}
N 18870 770 18880 770 {lab=n14_ff.ncki}
N 18870 770 18870 730 {lab=n14_ff.ncki}
N 18870 730 18960 730 {lab=n14_ff.ncki}
N 18960 730 18960 210 {lab=n14_ff.ncki}
N 18960 210 19080 210 {lab=n14_ff.ncki}
N 17440 890 17480 890 {lab=n15_ff.ncki}
N 17440 890 17440 90 {lab=n15_ff.ncki}
N 17480 890 17480 920 {lab=n15_ff.ncki}
N 17480 920 17750 920 {lab=n15_ff.ncki}
N 17750 920 17760 920 {lab=n15_ff.ncki}
N 17750 920 17750 860 {lab=n15_ff.ncki}
N 17440 90 17480 90 {lab=n15_ff.ncki}
N 17480 90 17480 60 {lab=n15_ff.ncki}
N 17480 60 17760 60 {lab=n15_ff.ncki}
N 17750 860 18980 860 {lab=n15_ff.ncki}
N 18980 860 18980 620 {lab=n15_ff.ncki}
N 18980 620 21430 620 {lab=n15_ff.ncki}
N 21430 620 21430 210 {lab=n15_ff.ncki}
N 21430 620 21630 620 {lab=n15_ff.ncki}
N 21630 620 21640 620 {lab=n15_ff.ncki}
N 21630 620 21630 660 {lab=n15_ff.ncki}
N 21430 210 21440 210 {lab=n15_ff.ncki}
N 21630 660 21740 660 {lab=n15_ff.ncki}
N 21740 660 21740 770 {lab=n15_ff.ncki}
N 21740 770 22190 770 {lab=n15_ff.ncki}
N 22190 770 22200 770 {lab=n15_ff.ncki}
N 22190 770 22190 730 {lab=n15_ff.ncki}
N 22190 730 22280 730 {lab=n15_ff.ncki}
N 22280 730 22280 210 {lab=n15_ff.ncki}
N 22280 210 22400 210 {lab=n15_ff.ncki}
N 26680 890 26680 90 {lab=n2_ff.ncki}
N 26680 890 26720 890 {lab=n2_ff.ncki}
N 26720 890 26720 920 {lab=n2_ff.ncki}
N 26720 920 26990 920 {lab=n2_ff.ncki}
N 26990 920 26990 860 {lab=n2_ff.ncki}
N 26990 920 27000 920 {lab=n2_ff.ncki}
N 26680 90 26720 90 {lab=n2_ff.ncki}
N 26720 90 26720 60 {lab=n2_ff.ncki}
N 26720 60 27000 60 {lab=n2_ff.ncki}
N 26990 860 28220 860 {lab=n2_ff.ncki}
N 28220 860 28220 620 {lab=n2_ff.ncki}
N 28220 620 30670 620 {lab=n2_ff.ncki}
N 30670 620 30670 210 {lab=n2_ff.ncki}
N 30670 620 30870 620 {lab=n2_ff.ncki}
N 30870 620 30880 620 {lab=n2_ff.ncki}
N 30870 620 30870 660 {lab=n2_ff.ncki}
N 30670 210 30680 210 {lab=n2_ff.ncki}
N 30870 660 30980 660 {lab=n2_ff.ncki}
N 30980 660 30980 770 {lab=n2_ff.ncki}
N 30980 770 31430 770 {lab=n2_ff.ncki}
N 31430 770 31430 730 {lab=n2_ff.ncki}
N 31430 770 31440 770 {lab=n2_ff.ncki}
N 31430 730 31520 730 {lab=n2_ff.ncki}
N 31520 730 31520 210 {lab=n2_ff.ncki}
N 31520 210 31640 210 {lab=n2_ff.ncki}
N 30000 890 30040 890 {lab=n3_ff.ncki}
N 30000 890 30000 90 {lab=n3_ff.ncki}
N 30040 890 30040 920 {lab=n3_ff.ncki}
N 30040 920 30310 920 {lab=n3_ff.ncki}
N 30310 920 30320 920 {lab=n3_ff.ncki}
N 30310 920 30310 860 {lab=n3_ff.ncki}
N 30000 90 30040 90 {lab=n3_ff.ncki}
N 30040 90 30040 60 {lab=n3_ff.ncki}
N 30040 60 30320 60 {lab=n3_ff.ncki}
N 30310 860 31540 860 {lab=n3_ff.ncki}
N 31540 860 31540 620 {lab=n3_ff.ncki}
N 31540 620 33990 620 {lab=n3_ff.ncki}
N 33990 620 34190 620 {lab=n3_ff.ncki}
N 33990 620 33990 210 {lab=n3_ff.ncki}
N 34190 620 34190 660 {lab=n3_ff.ncki}
N 34190 620 34200 620 {lab=n3_ff.ncki}
N 33990 210 34000 210 {lab=n3_ff.ncki}
N 34190 660 34300 660 {lab=n3_ff.ncki}
N 34300 660 34300 770 {lab=n3_ff.ncki}
N 34300 770 34750 770 {lab=n3_ff.ncki}
N 34750 770 34750 730 {lab=n3_ff.ncki}
N 34750 770 34760 770 {lab=n3_ff.ncki}
N 34750 730 34840 730 {lab=n3_ff.ncki}
N 34840 730 34840 210 {lab=n3_ff.ncki}
N 34840 210 34960 210 {lab=n3_ff.ncki}
N 33320 890 33360 890 {lab=n4_ff.ncki}
N 33320 890 33320 90 {lab=n4_ff.ncki}
N 33360 890 33360 920 {lab=n4_ff.ncki}
N 33360 920 33630 920 {lab=n4_ff.ncki}
N 33630 920 33640 920 {lab=n4_ff.ncki}
N 33630 920 33630 860 {lab=n4_ff.ncki}
N 33320 90 33360 90 {lab=n4_ff.ncki}
N 33360 90 33360 60 {lab=n4_ff.ncki}
N 33360 60 33640 60 {lab=n4_ff.ncki}
N 33630 860 34860 860 {lab=n4_ff.ncki}
N 34860 860 34860 620 {lab=n4_ff.ncki}
N 34860 620 37310 620 {lab=n4_ff.ncki}
N 37310 620 37510 620 {lab=n4_ff.ncki}
N 37310 620 37310 210 {lab=n4_ff.ncki}
N 37510 620 37510 660 {lab=n4_ff.ncki}
N 37510 620 37520 620 {lab=n4_ff.ncki}
N 37310 210 37320 210 {lab=n4_ff.ncki}
N 37510 660 37620 660 {lab=n4_ff.ncki}
N 37620 660 37620 770 {lab=n4_ff.ncki}
N 37620 770 38070 770 {lab=n4_ff.ncki}
N 38070 770 38080 770 {lab=n4_ff.ncki}
N 38070 770 38070 730 {lab=n4_ff.ncki}
N 38070 730 38160 730 {lab=n4_ff.ncki}
N 38160 730 38160 210 {lab=n4_ff.ncki}
N 38160 210 38280 210 {lab=n4_ff.ncki}
N 36640 890 36640 90 {lab=n5_ff.ncki}
N 36640 890 36680 890 {lab=n5_ff.ncki}
N 36680 890 36680 920 {lab=n5_ff.ncki}
N 36680 920 36950 920 {lab=n5_ff.ncki}
N 36950 920 36950 860 {lab=n5_ff.ncki}
N 36950 920 36960 920 {lab=n5_ff.ncki}
N 36640 90 36680 90 {lab=n5_ff.ncki}
N 36680 90 36680 60 {lab=n5_ff.ncki}
N 36680 60 36960 60 {lab=n5_ff.ncki}
N 36950 860 38180 860 {lab=n5_ff.ncki}
N 38180 860 38180 620 {lab=n5_ff.ncki}
N 38180 620 40630 620 {lab=n5_ff.ncki}
N 40630 620 40630 210 {lab=n5_ff.ncki}
N 40630 620 40830 620 {lab=n5_ff.ncki}
N 40830 620 40840 620 {lab=n5_ff.ncki}
N 40830 620 40830 660 {lab=n5_ff.ncki}
N 40630 210 40640 210 {lab=n5_ff.ncki}
N 40830 660 40940 660 {lab=n5_ff.ncki}
N 40940 660 40940 770 {lab=n5_ff.ncki}
N 40940 770 41390 770 {lab=n5_ff.ncki}
N 41390 770 41390 730 {lab=n5_ff.ncki}
N 41390 770 41400 770 {lab=n5_ff.ncki}
N 41390 730 41480 730 {lab=n5_ff.ncki}
N 41480 730 41480 210 {lab=n5_ff.ncki}
N 41480 210 41600 210 {lab=n5_ff.ncki}
N 39960 890 40000 890 {lab=n6_ff.ncki}
N 39960 890 39960 90 {lab=n6_ff.ncki}
N 40000 890 40000 920 {lab=n6_ff.ncki}
N 40000 920 40270 920 {lab=n6_ff.ncki}
N 40270 920 40270 860 {lab=n6_ff.ncki}
N 40270 920 40280 920 {lab=n6_ff.ncki}
N 39960 90 40000 90 {lab=n6_ff.ncki}
N 40000 90 40000 60 {lab=n6_ff.ncki}
N 40000 60 40280 60 {lab=n6_ff.ncki}
N 40270 860 41500 860 {lab=n6_ff.ncki}
N 41500 860 41500 620 {lab=n6_ff.ncki}
N 41500 620 43950 620 {lab=n6_ff.ncki}
N 43950 620 44150 620 {lab=n6_ff.ncki}
N 43950 620 43950 210 {lab=n6_ff.ncki}
N 44150 620 44150 660 {lab=n6_ff.ncki}
N 44150 620 44160 620 {lab=n6_ff.ncki}
N 43950 210 43960 210 {lab=n6_ff.ncki}
N 44150 660 44260 660 {lab=n6_ff.ncki}
N 44260 660 44260 770 {lab=n6_ff.ncki}
N 44260 770 44710 770 {lab=n6_ff.ncki}
N 44710 770 44710 730 {lab=n6_ff.ncki}
N 44710 770 44720 770 {lab=n6_ff.ncki}
N 44710 730 44800 730 {lab=n6_ff.ncki}
N 44800 730 44800 210 {lab=n6_ff.ncki}
N 44800 210 44920 210 {lab=n6_ff.ncki}
N 43280 890 43320 890 {lab=n7_ff.ncki}
N 43280 890 43280 90 {lab=n7_ff.ncki}
N 43320 890 43320 920 {lab=n7_ff.ncki}
N 43320 920 43590 920 {lab=n7_ff.ncki}
N 43590 920 43600 920 {lab=n7_ff.ncki}
N 43590 920 43590 860 {lab=n7_ff.ncki}
N 43280 90 43320 90 {lab=n7_ff.ncki}
N 43320 90 43320 60 {lab=n7_ff.ncki}
N 43320 60 43600 60 {lab=n7_ff.ncki}
N 43590 860 44820 860 {lab=n7_ff.ncki}
N 44820 860 44820 620 {lab=n7_ff.ncki}
N 44820 620 47270 620 {lab=n7_ff.ncki}
N 47270 620 47470 620 {lab=n7_ff.ncki}
N 47270 620 47270 210 {lab=n7_ff.ncki}
N 47470 620 47470 660 {lab=n7_ff.ncki}
N 47470 620 47480 620 {lab=n7_ff.ncki}
N 47270 210 47280 210 {lab=n7_ff.ncki}
N 47470 660 47580 660 {lab=n7_ff.ncki}
N 47580 660 47580 770 {lab=n7_ff.ncki}
N 47580 770 48030 770 {lab=n7_ff.ncki}
N 48030 770 48040 770 {lab=n7_ff.ncki}
N 48030 770 48030 730 {lab=n7_ff.ncki}
N 48030 730 48120 730 {lab=n7_ff.ncki}
N 48120 730 48120 210 {lab=n7_ff.ncki}
N 48120 210 48240 210 {lab=n7_ff.ncki}
N 46600 890 46600 90 {lab=n8_ff.ncki}
N 46600 890 46640 890 {lab=n8_ff.ncki}
N 46640 890 46640 920 {lab=n8_ff.ncki}
N 46640 920 46910 920 {lab=n8_ff.ncki}
N 46910 920 46910 860 {lab=n8_ff.ncki}
N 46910 920 46920 920 {lab=n8_ff.ncki}
N 46600 90 46640 90 {lab=n8_ff.ncki}
N 46640 90 46640 60 {lab=n8_ff.ncki}
N 46640 60 46920 60 {lab=n8_ff.ncki}
N 46910 860 48140 860 {lab=n8_ff.ncki}
N 48140 860 48140 620 {lab=n8_ff.ncki}
N 48140 620 50590 620 {lab=n8_ff.ncki}
N 50590 620 50590 210 {lab=n8_ff.ncki}
N 50590 620 50790 620 {lab=n8_ff.ncki}
N 50790 620 50790 680 {lab=n8_ff.ncki}
N 50790 620 50800 620 {lab=n8_ff.ncki}
N 50590 210 50600 210 {lab=n8_ff.ncki}
N 50790 680 50900 680 {lab=n8_ff.ncki}
N 50900 680 50900 770 {lab=n8_ff.ncki}
N 50900 770 51350 770 {lab=n8_ff.ncki}
N 51350 770 51360 770 {lab=n8_ff.ncki}
N 51350 770 51350 730 {lab=n8_ff.ncki}
N 51350 730 51440 730 {lab=n8_ff.ncki}
N 51440 730 51440 210 {lab=n8_ff.ncki}
N 51440 210 51560 210 {lab=n8_ff.ncki}
N 20760 890 20760 90 {lab=n16_ff.ncki}
N 20760 890 20800 890 {lab=n16_ff.ncki}
N 20800 890 20800 920 {lab=n16_ff.ncki}
N 20800 920 21070 920 {lab=n16_ff.ncki}
N 21070 920 21070 860 {lab=n16_ff.ncki}
N 21070 920 21080 920 {lab=n16_ff.ncki}
N 20760 90 20800 90 {lab=n16_ff.ncki}
N 20800 90 20800 60 {lab=n16_ff.ncki}
N 20800 60 21080 60 {lab=n16_ff.ncki}
N 21070 860 22300 860 {lab=n16_ff.ncki}
N 22300 860 22300 620 {lab=n16_ff.ncki}
N 22300 620 24030 620 {lab=n16_ff.ncki}
N 24030 620 24230 620 {lab=n16_ff.ncki}
N 24030 620 24030 210 {lab=n16_ff.ncki}
N 24230 620 24230 660 {lab=n16_ff.ncki}
N 24230 620 24240 620 {lab=n16_ff.ncki}
N 24030 210 24040 210 {lab=n16_ff.ncki}
N 24230 660 24340 660 {lab=n16_ff.ncki}
N 24340 660 24340 770 {lab=n16_ff.ncki}
N 24340 770 24790 770 {lab=n16_ff.ncki}
N 24790 770 24800 770 {lab=n16_ff.ncki}
N 24790 770 24790 730 {lab=n16_ff.ncki}
N 24790 730 24880 730 {lab=n16_ff.ncki}
N 24880 730 24880 210 {lab=n16_ff.ncki}
N 24880 210 25000 210 {lab=n16_ff.ncki}
N 160 890 200 890 {lab=n0_ff.ncki}
N 160 890 160 620 {lab=n0_ff.ncki}
N 200 890 200 920 {lab=n0_ff.ncki}
N 200 920 480 920 {lab=n0_ff.ncki}
N 160 620 2830 620 {lab=n0_ff.ncki}
N 160 620 160 90 {lab=n0_ff.ncki}
N 160 90 200 90 {lab=n0_ff.ncki}
N 200 90 200 60 {lab=n0_ff.ncki}
N 200 60 480 60 {lab=n0_ff.ncki}
N 2830 620 3030 620 {lab=n0_ff.ncki}
N 2830 620 2830 210 {lab=n0_ff.ncki}
N 3030 620 3030 660 {lab=n0_ff.ncki}
N 3030 620 3040 620 {lab=n0_ff.ncki}
N 2830 210 2840 210 {lab=n0_ff.ncki}
N 3030 660 3140 660 {lab=n0_ff.ncki}
N 3140 660 3140 770 {lab=n0_ff.ncki}
N 3140 770 3590 770 {lab=n0_ff.ncki}
N 3590 770 3600 770 {lab=n0_ff.ncki}
N 3590 770 3590 730 {lab=n0_ff.ncki}
N 3590 730 3680 730 {lab=n0_ff.ncki}
N 3680 730 3680 210 {lab=n0_ff.ncki}
N 3680 210 3800 210 {lab=n0_ff.ncki}
N 5480 890 5480 620 {lab=n11_ff.ncki}
N 5480 890 5520 890 {lab=n11_ff.ncki}
N 5520 890 5520 920 {lab=n11_ff.ncki}
N 5520 920 5800 920 {lab=n11_ff.ncki}
N 5480 620 8150 620 {lab=n11_ff.ncki}
N 5480 620 5480 90 {lab=n11_ff.ncki}
N 5480 90 5520 90 {lab=n11_ff.ncki}
N 5520 90 5520 60 {lab=n11_ff.ncki}
N 5520 60 5800 60 {lab=n11_ff.ncki}
N 8150 620 8350 620 {lab=n11_ff.ncki}
N 8150 620 8150 210 {lab=n11_ff.ncki}
N 8350 620 8350 680 {lab=n11_ff.ncki}
N 8350 620 8360 620 {lab=n11_ff.ncki}
N 8150 210 8160 210 {lab=n11_ff.ncki}
N 8350 680 8460 680 {lab=n11_ff.ncki}
N 8460 680 8460 770 {lab=n11_ff.ncki}
N 8460 770 8910 770 {lab=n11_ff.ncki}
N 8910 770 8920 770 {lab=n11_ff.ncki}
N 8910 770 8910 730 {lab=n11_ff.ncki}
N 8910 730 9000 730 {lab=n11_ff.ncki}
N 9000 730 9000 210 {lab=n11_ff.ncki}
N 9000 210 9120 210 {lab=n11_ff.ncki}
N 52880 890 52880 620 {lab=n10_ff.ncki}
N 52880 890 52920 890 {lab=n10_ff.ncki}
N 52920 890 52920 920 {lab=n10_ff.ncki}
N 52920 920 53200 920 {lab=n10_ff.ncki}
N 52880 620 53910 620 {lab=n10_ff.ncki}
N 52880 620 52880 90 {lab=n10_ff.ncki}
N 52880 90 52920 90 {lab=n10_ff.ncki}
N 52920 90 52920 60 {lab=n10_ff.ncki}
N 52920 60 53200 60 {lab=n10_ff.ncki}
N 53910 620 54110 620 {lab=n10_ff.ncki}
N 53910 620 53910 210 {lab=n10_ff.ncki}
N 54110 620 54110 680 {lab=n10_ff.ncki}
N 54110 620 54120 620 {lab=n10_ff.ncki}
N 53910 210 53920 210 {lab=n10_ff.ncki}
N 54110 680 54220 680 {lab=n10_ff.ncki}
N 54220 680 54220 770 {lab=n10_ff.ncki}
N 54220 770 54670 770 {lab=n10_ff.ncki}
N 54670 770 54670 730 {lab=n10_ff.ncki}
N 54670 770 54680 770 {lab=n10_ff.ncki}
N 54670 730 54760 730 {lab=n10_ff.ncki}
N 54760 730 54760 210 {lab=n10_ff.ncki}
N 54760 210 54880 210 {lab=n10_ff.ncki}
N 54880 920 54870 920 {lab=n10_ff.net4}
N 54870 920 54870 60 {lab=n10_ff.net4}
N 54870 920 54870 1000 {lab=n10_ff.net4}
N 54870 60 54880 60 {lab=n10_ff.net4}
N 54870 1000 4710 1000 {lab=n10_ff.net4}
N 4710 1000 4710 920 {lab=n10_ff.net4}
N 4710 920 4720 920 {lab=n10_ff.net4}
N 4710 920 4710 740 {lab=n10_ff.net4}
N 4710 740 4200 740 {lab=n10_ff.net4}
N 4710 740 4710 90 {lab=n10_ff.net4}
N 4710 90 4400 90 {lab=n10_ff.net4}
N 4710 90 4710 60 {lab=n10_ff.net4}
N 4710 60 4720 60 {lab=n10_ff.net4}
N 4400 90 4400 100 {lab=n10_ff.net4}
N 4400 100 4200 100 {lab=n10_ff.net4}
N 4200 100 4200 90 {lab=n10_ff.net4}
N 56200 920 56190 920 {lab=n9_ff.net4}
N 56190 920 56190 980 {lab=n9_ff.net4}
N 56190 920 56190 60 {lab=n9_ff.net4}
N 56190 60 56200 60 {lab=n9_ff.net4}
N 56190 980 52470 980 {lab=n9_ff.net4}
N 52470 980 52470 920 {lab=n9_ff.net4}
N 52470 920 52480 920 {lab=n9_ff.net4}
N 52470 920 52470 740 {lab=n9_ff.net4}
N 52470 740 51960 740 {lab=n9_ff.net4}
N 52470 740 52470 90 {lab=n9_ff.net4}
N 52470 90 52160 90 {lab=n9_ff.net4}
N 52470 90 52470 60 {lab=n9_ff.net4}
N 52470 60 52480 60 {lab=n9_ff.net4}
N 52160 90 52160 100 {lab=n9_ff.net4}
N 52160 100 51960 100 {lab=n9_ff.net4}
N 51960 100 51960 90 {lab=n9_ff.net4}
N 3800 920 3790 920 {lab=n0_ff.net4}
N 3790 920 3790 860 {lab=n0_ff.net4}
N 3790 860 1390 860 {lab=n0_ff.net4}
N 3790 860 3790 60 {lab=n0_ff.net4}
N 3790 60 3800 60 {lab=n0_ff.net4}
N 1390 860 1390 740 {lab=n0_ff.net4}
N 1390 860 1390 920 {lab=n0_ff.net4}
N 1390 920 1400 920 {lab=n0_ff.net4}
N 1390 740 1390 90 {lab=n0_ff.net4}
N 1390 740 880 740 {lab=n0_ff.net4}
N 1390 90 1080 90 {lab=n0_ff.net4}
N 1390 90 1390 60 {lab=n0_ff.net4}
N 1390 60 1400 60 {lab=n0_ff.net4}
N 1080 90 1080 100 {lab=n0_ff.net4}
N 1080 100 880 100 {lab=n0_ff.net4}
N 880 100 880 90 {lab=n0_ff.net4}
N 9120 920 9110 920 {lab=n11_ff.net4}
N 9110 920 9110 860 {lab=n11_ff.net4}
N 9110 860 6710 860 {lab=n11_ff.net4}
N 9110 860 9110 60 {lab=n11_ff.net4}
N 9110 60 9120 60 {lab=n11_ff.net4}
N 6710 860 6710 740 {lab=n11_ff.net4}
N 6710 860 6710 920 {lab=n11_ff.net4}
N 6710 920 6720 920 {lab=n11_ff.net4}
N 6710 740 6200 740 {lab=n11_ff.net4}
N 6710 740 6710 90 {lab=n11_ff.net4}
N 6710 90 6400 90 {lab=n11_ff.net4}
N 6710 90 6710 60 {lab=n11_ff.net4}
N 6710 60 6720 60 {lab=n11_ff.net4}
N 6400 90 6400 100 {lab=n11_ff.net4}
N 6400 100 6200 100 {lab=n11_ff.net4}
N 6200 100 6200 90 {lab=n11_ff.net4}
N 12440 920 12430 920 {lab=n12_ff.net4}
N 12430 920 12430 840 {lab=n12_ff.net4}
N 12430 840 10030 840 {lab=n12_ff.net4}
N 12430 840 12430 60 {lab=n12_ff.net4}
N 12430 60 12440 60 {lab=n12_ff.net4}
N 10030 840 10030 740 {lab=n12_ff.net4}
N 10030 840 10030 920 {lab=n12_ff.net4}
N 10030 920 10040 920 {lab=n12_ff.net4}
N 10030 740 9520 740 {lab=n12_ff.net4}
N 10030 740 10030 90 {lab=n12_ff.net4}
N 10030 90 9720 90 {lab=n12_ff.net4}
N 10030 90 10030 60 {lab=n12_ff.net4}
N 10030 60 10040 60 {lab=n12_ff.net4}
N 9720 90 9720 100 {lab=n12_ff.net4}
N 9720 100 9520 100 {lab=n12_ff.net4}
N 9520 100 9520 90 {lab=n12_ff.net4}
N 15760 920 15750 920 {lab=n13_ff.net4}
N 15750 920 15750 840 {lab=n13_ff.net4}
N 15750 840 13350 840 {lab=n13_ff.net4}
N 15750 840 15750 60 {lab=n13_ff.net4}
N 15750 60 15760 60 {lab=n13_ff.net4}
N 13350 840 13350 740 {lab=n13_ff.net4}
N 13350 840 13350 920 {lab=n13_ff.net4}
N 13350 920 13360 920 {lab=n13_ff.net4}
N 13350 740 12840 740 {lab=n13_ff.net4}
N 13350 740 13350 90 {lab=n13_ff.net4}
N 13350 90 13040 90 {lab=n13_ff.net4}
N 13350 90 13350 60 {lab=n13_ff.net4}
N 13350 60 13360 60 {lab=n13_ff.net4}
N 13040 90 13040 100 {lab=n13_ff.net4}
N 13040 100 12840 100 {lab=n13_ff.net4}
N 12840 100 12840 90 {lab=n13_ff.net4}
N 19080 920 19070 920 {lab=n14_ff.net4}
N 19070 920 19070 840 {lab=n14_ff.net4}
N 19070 840 19070 60 {lab=n14_ff.net4}
N 19070 840 16670 840 {lab=n14_ff.net4}
N 19070 60 19080 60 {lab=n14_ff.net4}
N 16670 840 16670 920 {lab=n14_ff.net4}
N 16670 840 16670 740 {lab=n14_ff.net4}
N 16670 920 16680 920 {lab=n14_ff.net4}
N 16670 740 16160 740 {lab=n14_ff.net4}
N 16670 740 16670 90 {lab=n14_ff.net4}
N 16670 90 16360 90 {lab=n14_ff.net4}
N 16670 90 16670 60 {lab=n14_ff.net4}
N 16670 60 16680 60 {lab=n14_ff.net4}
N 16360 90 16360 100 {lab=n14_ff.net4}
N 16360 100 16160 100 {lab=n14_ff.net4}
N 16160 100 16160 90 {lab=n14_ff.net4}
N 22400 920 22390 920 {lab=n15_ff.net4}
N 22390 920 22390 840 {lab=n15_ff.net4}
N 22390 840 19990 840 {lab=n15_ff.net4}
N 22390 840 22390 60 {lab=n15_ff.net4}
N 22390 60 22400 60 {lab=n15_ff.net4}
N 19990 840 19990 920 {lab=n15_ff.net4}
N 19990 840 19990 740 {lab=n15_ff.net4}
N 19990 920 20000 920 {lab=n15_ff.net4}
N 19990 740 19990 90 {lab=n15_ff.net4}
N 19990 740 19480 740 {lab=n15_ff.net4}
N 19990 90 19680 90 {lab=n15_ff.net4}
N 19990 90 19990 60 {lab=n15_ff.net4}
N 19990 60 20000 60 {lab=n15_ff.net4}
N 19680 90 19680 100 {lab=n15_ff.net4}
N 19680 100 19480 100 {lab=n15_ff.net4}
N 19480 100 19480 90 {lab=n15_ff.net4}
N 28320 920 28310 920 {lab=n1_ff.net4}
N 28310 920 28310 980 {lab=n1_ff.net4}
N 28310 920 28310 60 {lab=n1_ff.net4}
N 28310 60 28320 60 {lab=n1_ff.net4}
N 28310 980 25910 980 {lab=n1_ff.net4}
N 25910 980 25910 920 {lab=n1_ff.net4}
N 25910 920 25910 740 {lab=n1_ff.net4}
N 25910 920 25920 920 {lab=n1_ff.net4}
N 25910 740 25910 90 {lab=n1_ff.net4}
N 25910 740 25400 740 {lab=n1_ff.net4}
N 25910 90 25600 90 {lab=n1_ff.net4}
N 25910 90 25910 60 {lab=n1_ff.net4}
N 25910 60 25920 60 {lab=n1_ff.net4}
N 25600 90 25600 100 {lab=n1_ff.net4}
N 25600 100 25400 100 {lab=n1_ff.net4}
N 25400 100 25400 90 {lab=n1_ff.net4}
N 31640 920 31630 920 {lab=n2_ff.net4}
N 31630 920 31630 60 {lab=n2_ff.net4}
N 31630 920 31630 980 {lab=n2_ff.net4}
N 31630 60 31640 60 {lab=n2_ff.net4}
N 31630 980 29230 980 {lab=n2_ff.net4}
N 29230 980 29230 920 {lab=n2_ff.net4}
N 29230 920 29240 920 {lab=n2_ff.net4}
N 29230 920 29230 740 {lab=n2_ff.net4}
N 29230 740 28720 740 {lab=n2_ff.net4}
N 29230 740 29230 90 {lab=n2_ff.net4}
N 29230 90 29230 60 {lab=n2_ff.net4}
N 29230 90 28920 90 {lab=n2_ff.net4}
N 29230 60 29240 60 {lab=n2_ff.net4}
N 28920 90 28920 100 {lab=n2_ff.net4}
N 28920 100 28720 100 {lab=n2_ff.net4}
N 28720 100 28720 90 {lab=n2_ff.net4}
N 34960 920 34950 920 {lab=n3_ff.net4}
N 34950 920 34950 60 {lab=n3_ff.net4}
N 34950 920 34950 980 {lab=n3_ff.net4}
N 34950 60 34960 60 {lab=n3_ff.net4}
N 34950 980 32550 980 {lab=n3_ff.net4}
N 32550 980 32550 920 {lab=n3_ff.net4}
N 32550 920 32560 920 {lab=n3_ff.net4}
N 32550 920 32550 740 {lab=n3_ff.net4}
N 32550 740 32040 740 {lab=n3_ff.net4}
N 32550 740 32550 90 {lab=n3_ff.net4}
N 32550 90 32240 90 {lab=n3_ff.net4}
N 32550 90 32550 60 {lab=n3_ff.net4}
N 32550 60 32560 60 {lab=n3_ff.net4}
N 32240 90 32240 100 {lab=n3_ff.net4}
N 32240 100 32040 100 {lab=n3_ff.net4}
N 32040 100 32040 90 {lab=n3_ff.net4}
N 38280 920 38270 920 {lab=n4_ff.net4}
N 38270 920 38270 60 {lab=n4_ff.net4}
N 38270 920 38270 980 {lab=n4_ff.net4}
N 38270 60 38280 60 {lab=n4_ff.net4}
N 38270 980 35870 980 {lab=n4_ff.net4}
N 35870 980 35870 920 {lab=n4_ff.net4}
N 35870 920 35870 740 {lab=n4_ff.net4}
N 35870 920 35880 920 {lab=n4_ff.net4}
N 35870 740 35870 90 {lab=n4_ff.net4}
N 35870 740 35360 740 {lab=n4_ff.net4}
N 35870 90 35560 90 {lab=n4_ff.net4}
N 35870 90 35870 60 {lab=n4_ff.net4}
N 35870 60 35880 60 {lab=n4_ff.net4}
N 35560 90 35560 100 {lab=n4_ff.net4}
N 35560 100 35360 100 {lab=n4_ff.net4}
N 35360 100 35360 90 {lab=n4_ff.net4}
N 41600 920 41590 920 {lab=n5_ff.net4}
N 41590 920 41590 980 {lab=n5_ff.net4}
N 41590 920 41590 60 {lab=n5_ff.net4}
N 41590 60 41600 60 {lab=n5_ff.net4}
N 41590 980 39190 980 {lab=n5_ff.net4}
N 39190 980 39190 920 {lab=n5_ff.net4}
N 39190 920 39200 920 {lab=n5_ff.net4}
N 39190 920 39190 740 {lab=n5_ff.net4}
N 39190 740 38680 740 {lab=n5_ff.net4}
N 39190 740 39190 90 {lab=n5_ff.net4}
N 39190 90 38880 90 {lab=n5_ff.net4}
N 39190 90 39190 60 {lab=n5_ff.net4}
N 39190 60 39200 60 {lab=n5_ff.net4}
N 38880 90 38880 100 {lab=n5_ff.net4}
N 38880 100 38680 100 {lab=n5_ff.net4}
N 38680 100 38680 90 {lab=n5_ff.net4}
N 44920 920 44910 920 {lab=n6_ff.net4}
N 44910 920 44910 60 {lab=n6_ff.net4}
N 44910 920 44910 980 {lab=n6_ff.net4}
N 44910 60 44920 60 {lab=n6_ff.net4}
N 44910 980 42510 980 {lab=n6_ff.net4}
N 42510 980 42510 920 {lab=n6_ff.net4}
N 42510 920 42520 920 {lab=n6_ff.net4}
N 42510 920 42510 740 {lab=n6_ff.net4}
N 42510 740 42000 740 {lab=n6_ff.net4}
N 42510 740 42510 90 {lab=n6_ff.net4}
N 42510 90 42510 60 {lab=n6_ff.net4}
N 42510 90 42200 90 {lab=n6_ff.net4}
N 42510 60 42520 60 {lab=n6_ff.net4}
N 42200 90 42200 100 {lab=n6_ff.net4}
N 42200 100 42000 100 {lab=n6_ff.net4}
N 42000 100 42000 90 {lab=n6_ff.net4}
N 48240 920 48230 920 {lab=n7_ff.net4}
N 48230 920 48230 60 {lab=n7_ff.net4}
N 48230 920 48230 980 {lab=n7_ff.net4}
N 48230 60 48240 60 {lab=n7_ff.net4}
N 48230 980 45830 980 {lab=n7_ff.net4}
N 45830 980 45830 920 {lab=n7_ff.net4}
N 45830 920 45830 740 {lab=n7_ff.net4}
N 45830 920 45840 920 {lab=n7_ff.net4}
N 45830 740 45830 90 {lab=n7_ff.net4}
N 45830 740 45320 740 {lab=n7_ff.net4}
N 45830 90 45830 60 {lab=n7_ff.net4}
N 45830 90 45520 90 {lab=n7_ff.net4}
N 45830 60 45840 60 {lab=n7_ff.net4}
N 45520 90 45520 100 {lab=n7_ff.net4}
N 45520 100 45320 100 {lab=n7_ff.net4}
N 45320 100 45320 90 {lab=n7_ff.net4}
N 51560 920 51550 920 {lab=n8_ff.net4}
N 51550 920 51550 980 {lab=n8_ff.net4}
N 51550 920 51550 60 {lab=n8_ff.net4}
N 51550 60 51560 60 {lab=n8_ff.net4}
N 51550 980 49150 980 {lab=n8_ff.net4}
N 49150 980 49150 920 {lab=n8_ff.net4}
N 49150 920 49160 920 {lab=n8_ff.net4}
N 49150 920 49150 740 {lab=n8_ff.net4}
N 49150 740 48640 740 {lab=n8_ff.net4}
N 49150 740 49150 90 {lab=n8_ff.net4}
N 49150 90 48840 90 {lab=n8_ff.net4}
N 49150 90 49150 60 {lab=n8_ff.net4}
N 49150 60 49160 60 {lab=n8_ff.net4}
N 48840 90 48840 100 {lab=n8_ff.net4}
N 48840 100 48640 100 {lab=n8_ff.net4}
N 48640 100 48640 90 {lab=n8_ff.net4}
N 25000 920 24990 920 {lab=n16_ff.net4}
N 24990 920 24990 860 {lab=n16_ff.net4}
N 24990 860 23310 860 {lab=n16_ff.net4}
N 24990 860 24990 60 {lab=n16_ff.net4}
N 24990 60 25000 60 {lab=n16_ff.net4}
N 23310 860 23310 740 {lab=n16_ff.net4}
N 23310 860 23310 920 {lab=n16_ff.net4}
N 23310 920 23320 920 {lab=n16_ff.net4}
N 23310 740 22800 740 {lab=n16_ff.net4}
N 23310 740 23310 90 {lab=n16_ff.net4}
N 23310 90 23310 60 {lab=n16_ff.net4}
N 23310 90 23000 90 {lab=n16_ff.net4}
N 23310 60 23320 60 {lab=n16_ff.net4}
N 23000 90 23000 100 {lab=n16_ff.net4}
N 23000 100 22800 100 {lab=n16_ff.net4}
N 22800 100 22800 90 {lab=n16_ff.net4}
N 54720 740 54720 710 {lab=n10_ff.net8}
N 54720 710 54720 250 {lab=n10_ff.net8}
N 54720 710 54780 710 {lab=n10_ff.net8}
N 54780 710 54780 1020 {lab=n10_ff.net8}
N 54780 710 54920 710 {lab=n10_ff.net8}
N 54920 710 54920 740 {lab=n10_ff.net8}
N 54720 250 54920 250 {lab=n10_ff.net8}
N 54720 250 54720 240 {lab=n10_ff.net8}
N 54920 250 54920 240 {lab=n10_ff.net8}
N 54780 1020 4350 1020 {lab=n10_ff.net8}
N 4350 1020 4350 60 {lab=n10_ff.net8}
N 4350 1020 4130 1020 {lab=n10_ff.net8}
N 4130 1020 4130 770 {lab=n10_ff.net8}
N 4130 770 4160 770 {lab=n10_ff.net8}
N 4350 60 4360 60 {lab=n10_ff.net8}
N 2520 890 2520 90 {lab=n1_ff.cki}
N 2520 890 2560 890 {lab=n1_ff.cki}
N 2560 890 2560 1040 {lab=n1_ff.cki}
N 2560 1040 25460 1040 {lab=n1_ff.cki}
N 25460 1040 25460 770 {lab=n1_ff.cki}
N 25460 770 27350 770 {lab=n1_ff.cki}
N 27350 770 27350 810 {lab=n1_ff.cki}
N 27350 770 27360 770 {lab=n1_ff.cki}
N 27350 810 27750 810 {lab=n1_ff.cki}
N 27750 810 27750 250 {lab=n1_ff.cki}
N 27750 810 28200 810 {lab=n1_ff.cki}
N 28200 810 28200 770 {lab=n1_ff.cki}
N 28200 770 28320 770 {lab=n1_ff.cki}
N 27750 250 27750 210 {lab=n1_ff.cki}
N 27750 250 27840 250 {lab=n1_ff.cki}
N 27750 210 27760 210 {lab=n1_ff.cki}
N 27840 250 27840 210 {lab=n1_ff.cki}
N 27840 210 28120 210 {lab=n1_ff.cki}
N 50280 890 50280 810 {lab=n9_ff.cki}
N 50280 810 50280 90 {lab=n9_ff.cki}
N 50280 810 54960 810 {lab=n9_ff.cki}
N 54960 810 54960 770 {lab=n9_ff.cki}
N 54960 770 55230 770 {lab=n9_ff.cki}
N 55230 770 55230 810 {lab=n9_ff.cki}
N 55230 770 55240 770 {lab=n9_ff.cki}
N 55230 810 55630 810 {lab=n9_ff.cki}
N 55630 810 55630 250 {lab=n9_ff.cki}
N 55630 810 56080 810 {lab=n9_ff.cki}
N 56080 810 56080 770 {lab=n9_ff.cki}
N 56080 770 56200 770 {lab=n9_ff.cki}
N 55630 250 55630 210 {lab=n9_ff.cki}
N 55630 250 55720 250 {lab=n9_ff.cki}
N 55630 210 55640 210 {lab=n9_ff.cki}
N 55720 250 55720 210 {lab=n9_ff.cki}
N 55720 210 56000 210 {lab=n9_ff.cki}
N 7840 890 7840 810 {lab=n12_ff.cki}
N 7840 810 9560 810 {lab=n12_ff.cki}
N 7840 810 7840 90 {lab=n12_ff.cki}
N 9560 810 9560 770 {lab=n12_ff.cki}
N 9560 770 11470 770 {lab=n12_ff.cki}
N 11470 770 11470 810 {lab=n12_ff.cki}
N 11470 770 11480 770 {lab=n12_ff.cki}
N 11470 810 11870 810 {lab=n12_ff.cki}
N 11870 810 11870 250 {lab=n12_ff.cki}
N 11870 810 12320 810 {lab=n12_ff.cki}
N 12320 810 12320 770 {lab=n12_ff.cki}
N 12320 770 12440 770 {lab=n12_ff.cki}
N 11870 250 11870 210 {lab=n12_ff.cki}
N 11870 250 11960 250 {lab=n12_ff.cki}
N 11870 210 11880 210 {lab=n12_ff.cki}
N 11960 250 11960 210 {lab=n12_ff.cki}
N 11960 210 12240 210 {lab=n12_ff.cki}
N 11160 890 11160 710 {lab=n13_ff.cki}
N 11160 710 11160 90 {lab=n13_ff.cki}
N 11160 710 13370 710 {lab=n13_ff.cki}
N 13370 710 13370 770 {lab=n13_ff.cki}
N 13370 770 14790 770 {lab=n13_ff.cki}
N 14790 770 14790 810 {lab=n13_ff.cki}
N 14790 770 14800 770 {lab=n13_ff.cki}
N 14790 810 15190 810 {lab=n13_ff.cki}
N 15190 810 15640 810 {lab=n13_ff.cki}
N 15190 810 15190 250 {lab=n13_ff.cki}
N 15640 810 15640 770 {lab=n13_ff.cki}
N 15640 770 15760 770 {lab=n13_ff.cki}
N 15190 250 15280 250 {lab=n13_ff.cki}
N 15190 250 15190 210 {lab=n13_ff.cki}
N 15190 210 15200 210 {lab=n13_ff.cki}
N 15280 250 15280 210 {lab=n13_ff.cki}
N 15280 210 15560 210 {lab=n13_ff.cki}
N 14480 890 14480 710 {lab=n14_ff.cki}
N 14480 710 16690 710 {lab=n14_ff.cki}
N 14480 710 14480 90 {lab=n14_ff.cki}
N 16690 710 16690 770 {lab=n14_ff.cki}
N 16690 770 18110 770 {lab=n14_ff.cki}
N 18110 770 18110 810 {lab=n14_ff.cki}
N 18110 770 18120 770 {lab=n14_ff.cki}
N 18110 810 18510 810 {lab=n14_ff.cki}
N 18510 810 18960 810 {lab=n14_ff.cki}
N 18510 810 18510 250 {lab=n14_ff.cki}
N 18960 810 18960 770 {lab=n14_ff.cki}
N 18960 770 19080 770 {lab=n14_ff.cki}
N 18510 250 18510 210 {lab=n14_ff.cki}
N 18510 250 18600 250 {lab=n14_ff.cki}
N 18510 210 18520 210 {lab=n14_ff.cki}
N 18600 250 18600 210 {lab=n14_ff.cki}
N 18600 210 18880 210 {lab=n14_ff.cki}
N 17800 890 17800 710 {lab=n15_ff.cki}
N 17800 710 17800 90 {lab=n15_ff.cki}
N 17800 710 20010 710 {lab=n15_ff.cki}
N 20010 710 20010 770 {lab=n15_ff.cki}
N 20010 770 21430 770 {lab=n15_ff.cki}
N 21430 770 21440 770 {lab=n15_ff.cki}
N 21430 770 21430 810 {lab=n15_ff.cki}
N 21430 810 21830 810 {lab=n15_ff.cki}
N 21830 810 21830 250 {lab=n15_ff.cki}
N 21830 810 22280 810 {lab=n15_ff.cki}
N 22280 810 22280 770 {lab=n15_ff.cki}
N 22280 770 22400 770 {lab=n15_ff.cki}
N 21830 250 21830 210 {lab=n15_ff.cki}
N 21830 250 21920 250 {lab=n15_ff.cki}
N 21830 210 21840 210 {lab=n15_ff.cki}
N 21920 250 21920 210 {lab=n15_ff.cki}
N 21920 210 22200 210 {lab=n15_ff.cki}
N 27040 890 27040 830 {lab=n2_ff.cki}
N 27040 830 27040 90 {lab=n2_ff.cki}
N 27040 830 28760 830 {lab=n2_ff.cki}
N 28760 830 28760 770 {lab=n2_ff.cki}
N 28760 770 30670 770 {lab=n2_ff.cki}
N 30670 770 30670 810 {lab=n2_ff.cki}
N 30670 770 30680 770 {lab=n2_ff.cki}
N 30670 810 31070 810 {lab=n2_ff.cki}
N 31070 810 31520 810 {lab=n2_ff.cki}
N 31070 810 31070 250 {lab=n2_ff.cki}
N 31520 810 31520 770 {lab=n2_ff.cki}
N 31520 770 31640 770 {lab=n2_ff.cki}
N 31070 250 31160 250 {lab=n2_ff.cki}
N 31070 250 31070 210 {lab=n2_ff.cki}
N 31070 210 31080 210 {lab=n2_ff.cki}
N 31160 250 31160 210 {lab=n2_ff.cki}
N 31160 210 31440 210 {lab=n2_ff.cki}
N 30360 890 30360 830 {lab=n3_ff.cki}
N 30360 830 32080 830 {lab=n3_ff.cki}
N 30360 830 30360 90 {lab=n3_ff.cki}
N 32080 830 32080 770 {lab=n3_ff.cki}
N 32080 770 33990 770 {lab=n3_ff.cki}
N 33990 770 34000 770 {lab=n3_ff.cki}
N 33990 770 33990 810 {lab=n3_ff.cki}
N 33990 810 34390 810 {lab=n3_ff.cki}
N 34390 810 34390 250 {lab=n3_ff.cki}
N 34390 810 34840 810 {lab=n3_ff.cki}
N 34840 810 34840 770 {lab=n3_ff.cki}
N 34840 770 34960 770 {lab=n3_ff.cki}
N 34390 250 34480 250 {lab=n3_ff.cki}
N 34390 250 34390 210 {lab=n3_ff.cki}
N 34390 210 34400 210 {lab=n3_ff.cki}
N 34480 250 34480 210 {lab=n3_ff.cki}
N 34480 210 34760 210 {lab=n3_ff.cki}
N 33680 890 33680 830 {lab=n4_ff.cki}
N 33680 830 35400 830 {lab=n4_ff.cki}
N 33680 830 33680 90 {lab=n4_ff.cki}
N 35400 830 35400 770 {lab=n4_ff.cki}
N 35400 770 37310 770 {lab=n4_ff.cki}
N 37310 770 37320 770 {lab=n4_ff.cki}
N 37310 770 37310 810 {lab=n4_ff.cki}
N 37310 810 37710 810 {lab=n4_ff.cki}
N 37710 810 37710 250 {lab=n4_ff.cki}
N 37710 810 38160 810 {lab=n4_ff.cki}
N 38160 810 38160 770 {lab=n4_ff.cki}
N 38160 770 38280 770 {lab=n4_ff.cki}
N 37710 250 37710 210 {lab=n4_ff.cki}
N 37710 250 37800 250 {lab=n4_ff.cki}
N 37710 210 37720 210 {lab=n4_ff.cki}
N 37800 250 37800 210 {lab=n4_ff.cki}
N 37800 210 38080 210 {lab=n4_ff.cki}
N 37000 890 37000 830 {lab=n5_ff.cki}
N 37000 830 37000 90 {lab=n5_ff.cki}
N 37000 830 38720 830 {lab=n5_ff.cki}
N 38720 830 38720 770 {lab=n5_ff.cki}
N 38720 770 40630 770 {lab=n5_ff.cki}
N 40630 770 40630 810 {lab=n5_ff.cki}
N 40630 770 40640 770 {lab=n5_ff.cki}
N 40630 810 41030 810 {lab=n5_ff.cki}
N 41030 810 41030 250 {lab=n5_ff.cki}
N 41030 810 41480 810 {lab=n5_ff.cki}
N 41480 810 41480 770 {lab=n5_ff.cki}
N 41480 770 41600 770 {lab=n5_ff.cki}
N 41030 250 41030 210 {lab=n5_ff.cki}
N 41030 250 41120 250 {lab=n5_ff.cki}
N 41030 210 41040 210 {lab=n5_ff.cki}
N 41120 250 41120 210 {lab=n5_ff.cki}
N 41120 210 41400 210 {lab=n5_ff.cki}
N 40320 890 40320 830 {lab=n6_ff.cki}
N 40320 830 42040 830 {lab=n6_ff.cki}
N 40320 830 40320 90 {lab=n6_ff.cki}
N 42040 830 42040 770 {lab=n6_ff.cki}
N 42040 770 43950 770 {lab=n6_ff.cki}
N 43950 770 43950 810 {lab=n6_ff.cki}
N 43950 770 43960 770 {lab=n6_ff.cki}
N 43950 810 44350 810 {lab=n6_ff.cki}
N 44350 810 44800 810 {lab=n6_ff.cki}
N 44350 810 44350 250 {lab=n6_ff.cki}
N 44800 810 44800 770 {lab=n6_ff.cki}
N 44800 770 44920 770 {lab=n6_ff.cki}
N 44350 250 44440 250 {lab=n6_ff.cki}
N 44350 250 44350 210 {lab=n6_ff.cki}
N 44350 210 44360 210 {lab=n6_ff.cki}
N 44440 250 44440 210 {lab=n6_ff.cki}
N 44440 210 44720 210 {lab=n6_ff.cki}
N 43640 890 43640 830 {lab=n7_ff.cki}
N 43640 830 45360 830 {lab=n7_ff.cki}
N 43640 830 43640 90 {lab=n7_ff.cki}
N 45360 830 45360 770 {lab=n7_ff.cki}
N 45360 770 47270 770 {lab=n7_ff.cki}
N 47270 770 47280 770 {lab=n7_ff.cki}
N 47270 770 47270 810 {lab=n7_ff.cki}
N 47270 810 47670 810 {lab=n7_ff.cki}
N 47670 810 47670 250 {lab=n7_ff.cki}
N 47670 810 48120 810 {lab=n7_ff.cki}
N 48120 810 48120 770 {lab=n7_ff.cki}
N 48120 770 48240 770 {lab=n7_ff.cki}
N 47670 250 47760 250 {lab=n7_ff.cki}
N 47670 250 47670 210 {lab=n7_ff.cki}
N 47670 210 47680 210 {lab=n7_ff.cki}
N 47760 250 47760 210 {lab=n7_ff.cki}
N 47760 210 48040 210 {lab=n7_ff.cki}
N 46960 890 46960 830 {lab=n8_ff.cki}
N 46960 830 46960 90 {lab=n8_ff.cki}
N 46960 830 48680 830 {lab=n8_ff.cki}
N 48680 830 48680 770 {lab=n8_ff.cki}
N 48680 770 50590 770 {lab=n8_ff.cki}
N 50590 770 50590 830 {lab=n8_ff.cki}
N 50590 770 50600 770 {lab=n8_ff.cki}
N 50590 830 50990 830 {lab=n8_ff.cki}
N 50990 830 51440 830 {lab=n8_ff.cki}
N 50990 830 50990 250 {lab=n8_ff.cki}
N 51440 830 51440 770 {lab=n8_ff.cki}
N 51440 770 51560 770 {lab=n8_ff.cki}
N 50990 250 51080 250 {lab=n8_ff.cki}
N 50990 250 50990 210 {lab=n8_ff.cki}
N 50990 210 51000 210 {lab=n8_ff.cki}
N 51080 250 51080 210 {lab=n8_ff.cki}
N 51080 210 51360 210 {lab=n8_ff.cki}
N 56040 740 56040 710 {lab=n9_ff.net8}
N 56040 710 56240 710 {lab=n9_ff.net8}
N 56040 710 56040 690 {lab=n9_ff.net8}
N 56240 710 56240 740 {lab=n9_ff.net8}
N 56040 690 56040 250 {lab=n9_ff.net8}
N 56040 690 54700 690 {lab=n9_ff.net8}
N 56040 250 56040 240 {lab=n9_ff.net8}
N 56040 250 56240 250 {lab=n9_ff.net8}
N 56240 250 56240 240 {lab=n9_ff.net8}
N 54700 690 54700 700 {lab=n9_ff.net8}
N 54700 700 52110 700 {lab=n9_ff.net8}
N 52110 700 51890 700 {lab=n9_ff.net8}
N 52110 700 52110 60 {lab=n9_ff.net8}
N 51890 700 51890 770 {lab=n9_ff.net8}
N 51890 770 51920 770 {lab=n9_ff.net8}
N 52110 60 52120 60 {lab=n9_ff.net8}
N 21120 890 21120 710 {lab=n16_ff.cki}
N 21120 710 21120 90 {lab=n16_ff.cki}
N 21120 710 23330 710 {lab=n16_ff.cki}
N 23330 710 23330 770 {lab=n16_ff.cki}
N 23330 770 24030 770 {lab=n16_ff.cki}
N 24030 770 24030 810 {lab=n16_ff.cki}
N 24030 770 24040 770 {lab=n16_ff.cki}
N 24030 810 24430 810 {lab=n16_ff.cki}
N 24430 810 24430 250 {lab=n16_ff.cki}
N 24430 810 24880 810 {lab=n16_ff.cki}
N 24880 810 24880 770 {lab=n16_ff.cki}
N 24880 770 25000 770 {lab=n16_ff.cki}
N 24430 250 24430 210 {lab=n16_ff.cki}
N 24430 250 24520 250 {lab=n16_ff.cki}
N 24430 210 24440 210 {lab=n16_ff.cki}
N 24520 250 24520 210 {lab=n16_ff.cki}
N 24520 210 24800 210 {lab=n16_ff.cki}
N 520 890 520 810 {lab=n0_ff.cki}
N 520 810 520 90 {lab=n0_ff.cki}
N 520 810 920 810 {lab=n0_ff.cki}
N 920 810 920 770 {lab=n0_ff.cki}
N 920 770 2830 770 {lab=n0_ff.cki}
N 2830 770 2840 770 {lab=n0_ff.cki}
N 2830 770 2830 810 {lab=n0_ff.cki}
N 2830 810 3230 810 {lab=n0_ff.cki}
N 3230 810 3230 250 {lab=n0_ff.cki}
N 3230 810 3680 810 {lab=n0_ff.cki}
N 3680 810 3680 770 {lab=n0_ff.cki}
N 3680 770 3800 770 {lab=n0_ff.cki}
N 3230 250 3230 210 {lab=n0_ff.cki}
N 3230 250 3320 250 {lab=n0_ff.cki}
N 3230 210 3240 210 {lab=n0_ff.cki}
N 3320 250 3320 210 {lab=n0_ff.cki}
N 3320 210 3600 210 {lab=n0_ff.cki}
N 5840 890 5840 810 {lab=n11_ff.cki}
N 5840 810 5840 90 {lab=n11_ff.cki}
N 5840 810 6240 810 {lab=n11_ff.cki}
N 6240 810 6240 770 {lab=n11_ff.cki}
N 6240 770 8150 770 {lab=n11_ff.cki}
N 8150 770 8160 770 {lab=n11_ff.cki}
N 8150 770 8150 830 {lab=n11_ff.cki}
N 8150 830 8550 830 {lab=n11_ff.cki}
N 8550 830 8550 250 {lab=n11_ff.cki}
N 8550 830 9000 830 {lab=n11_ff.cki}
N 9000 830 9000 770 {lab=n11_ff.cki}
N 9000 770 9120 770 {lab=n11_ff.cki}
N 8550 250 8550 210 {lab=n11_ff.cki}
N 8550 250 8640 250 {lab=n11_ff.cki}
N 8550 210 8560 210 {lab=n11_ff.cki}
N 8640 250 8640 210 {lab=n11_ff.cki}
N 8640 210 8920 210 {lab=n11_ff.cki}
N 3640 740 3640 710 {lab=n0_ff.net8}
N 3640 710 1030 710 {lab=n0_ff.net8}
N 3640 710 3640 250 {lab=n0_ff.net8}
N 3640 710 3840 710 {lab=n0_ff.net8}
N 3840 710 3840 740 {lab=n0_ff.net8}
N 3640 250 3640 240 {lab=n0_ff.net8}
N 3640 250 3840 250 {lab=n0_ff.net8}
N 3840 250 3840 240 {lab=n0_ff.net8}
N 1030 710 1030 60 {lab=n0_ff.net8}
N 1030 710 810 710 {lab=n0_ff.net8}
N 810 710 810 770 {lab=n0_ff.net8}
N 810 770 840 770 {lab=n0_ff.net8}
N 1030 60 1040 60 {lab=n0_ff.net8}
N 8960 740 8960 710 {lab=n11_ff.net8}
N 8960 710 6350 710 {lab=n11_ff.net8}
N 8960 710 8960 250 {lab=n11_ff.net8}
N 8960 710 9160 710 {lab=n11_ff.net8}
N 9160 710 9160 740 {lab=n11_ff.net8}
N 8960 250 8960 240 {lab=n11_ff.net8}
N 8960 250 9160 250 {lab=n11_ff.net8}
N 9160 250 9160 240 {lab=n11_ff.net8}
N 6350 710 6130 710 {lab=n11_ff.net8}
N 6350 710 6350 60 {lab=n11_ff.net8}
N 6130 710 6130 770 {lab=n11_ff.net8}
N 6130 770 6160 770 {lab=n11_ff.net8}
N 6350 60 6360 60 {lab=n11_ff.net8}
N 12280 740 12280 690 {lab=n12_ff.net8}
N 12280 740 12360 740 {lab=n12_ff.net8}
N 12360 740 12360 730 {lab=n12_ff.net8}
N 12360 730 12480 730 {lab=n12_ff.net8}
N 12480 730 12480 740 {lab=n12_ff.net8}
N 12280 690 9670 690 {lab=n12_ff.net8}
N 12280 690 12280 250 {lab=n12_ff.net8}
N 12280 250 12480 250 {lab=n12_ff.net8}
N 12280 250 12280 240 {lab=n12_ff.net8}
N 12480 250 12480 240 {lab=n12_ff.net8}
N 9670 690 9450 690 {lab=n12_ff.net8}
N 9670 690 9670 60 {lab=n12_ff.net8}
N 9450 690 9450 770 {lab=n12_ff.net8}
N 9450 770 9480 770 {lab=n12_ff.net8}
N 9670 60 9680 60 {lab=n12_ff.net8}
N 15600 740 15600 690 {lab=n13_ff.net8}
N 15600 740 15680 740 {lab=n13_ff.net8}
N 15680 740 15680 730 {lab=n13_ff.net8}
N 15680 730 15800 730 {lab=n13_ff.net8}
N 15800 730 15800 740 {lab=n13_ff.net8}
N 15600 690 12990 690 {lab=n13_ff.net8}
N 15600 690 15600 250 {lab=n13_ff.net8}
N 15600 250 15800 250 {lab=n13_ff.net8}
N 15600 250 15600 240 {lab=n13_ff.net8}
N 15800 250 15800 240 {lab=n13_ff.net8}
N 12990 690 12770 690 {lab=n13_ff.net8}
N 12990 690 12990 60 {lab=n13_ff.net8}
N 12770 690 12770 770 {lab=n13_ff.net8}
N 12770 770 12800 770 {lab=n13_ff.net8}
N 12990 60 13000 60 {lab=n13_ff.net8}
N 18920 740 19000 740 {lab=n14_ff.net8}
N 18920 740 18920 690 {lab=n14_ff.net8}
N 19000 740 19000 730 {lab=n14_ff.net8}
N 19000 730 19120 730 {lab=n14_ff.net8}
N 19120 730 19120 740 {lab=n14_ff.net8}
N 18920 690 16310 690 {lab=n14_ff.net8}
N 18920 690 18920 250 {lab=n14_ff.net8}
N 18920 250 18920 240 {lab=n14_ff.net8}
N 18920 250 19120 250 {lab=n14_ff.net8}
N 19120 250 19120 240 {lab=n14_ff.net8}
N 16310 690 16090 690 {lab=n14_ff.net8}
N 16310 690 16310 60 {lab=n14_ff.net8}
N 16090 690 16090 770 {lab=n14_ff.net8}
N 16090 770 16120 770 {lab=n14_ff.net8}
N 16310 60 16320 60 {lab=n14_ff.net8}
N 22240 740 22320 740 {lab=n15_ff.net8}
N 22240 740 22240 690 {lab=n15_ff.net8}
N 22320 740 22320 730 {lab=n15_ff.net8}
N 22320 730 22440 730 {lab=n15_ff.net8}
N 22440 730 22440 740 {lab=n15_ff.net8}
N 22240 690 22240 250 {lab=n15_ff.net8}
N 22240 690 19630 690 {lab=n15_ff.net8}
N 22240 250 22240 240 {lab=n15_ff.net8}
N 22240 250 22440 250 {lab=n15_ff.net8}
N 22440 250 22440 240 {lab=n15_ff.net8}
N 19630 690 19630 60 {lab=n15_ff.net8}
N 19630 690 19410 690 {lab=n15_ff.net8}
N 19410 690 19410 770 {lab=n15_ff.net8}
N 19410 770 19440 770 {lab=n15_ff.net8}
N 19630 60 19640 60 {lab=n15_ff.net8}
N 28160 740 28160 710 {lab=n1_ff.net8}
N 28160 710 28360 710 {lab=n1_ff.net8}
N 28160 710 28160 250 {lab=n1_ff.net8}
N 28160 710 25550 710 {lab=n1_ff.net8}
N 28360 710 28360 740 {lab=n1_ff.net8}
N 28160 250 28160 240 {lab=n1_ff.net8}
N 28160 250 28360 250 {lab=n1_ff.net8}
N 28360 250 28360 240 {lab=n1_ff.net8}
N 25550 710 25330 710 {lab=n1_ff.net8}
N 25550 710 25550 60 {lab=n1_ff.net8}
N 25330 710 25330 770 {lab=n1_ff.net8}
N 25330 770 25360 770 {lab=n1_ff.net8}
N 25550 60 25560 60 {lab=n1_ff.net8}
N 31480 740 31480 710 {lab=n2_ff.net8}
N 31480 710 31680 710 {lab=n2_ff.net8}
N 31480 710 28870 710 {lab=n2_ff.net8}
N 31480 710 31480 250 {lab=n2_ff.net8}
N 31680 710 31680 740 {lab=n2_ff.net8}
N 31480 250 31680 250 {lab=n2_ff.net8}
N 31480 250 31480 240 {lab=n2_ff.net8}
N 31680 250 31680 240 {lab=n2_ff.net8}
N 28870 710 28650 710 {lab=n2_ff.net8}
N 28870 710 28870 60 {lab=n2_ff.net8}
N 28650 710 28650 770 {lab=n2_ff.net8}
N 28650 770 28680 770 {lab=n2_ff.net8}
N 28870 60 28880 60 {lab=n2_ff.net8}
N 34800 740 34800 710 {lab=n3_ff.net8}
N 34800 710 35000 710 {lab=n3_ff.net8}
N 34800 710 34800 250 {lab=n3_ff.net8}
N 34800 710 32190 710 {lab=n3_ff.net8}
N 35000 710 35000 740 {lab=n3_ff.net8}
N 34800 250 34800 240 {lab=n3_ff.net8}
N 34800 250 35000 250 {lab=n3_ff.net8}
N 35000 250 35000 240 {lab=n3_ff.net8}
N 32190 710 31970 710 {lab=n3_ff.net8}
N 32190 710 32190 60 {lab=n3_ff.net8}
N 31970 710 31970 770 {lab=n3_ff.net8}
N 31970 770 32000 770 {lab=n3_ff.net8}
N 32190 60 32200 60 {lab=n3_ff.net8}
N 38120 740 38120 710 {lab=n4_ff.net8}
N 38120 710 38320 710 {lab=n4_ff.net8}
N 38120 710 35510 710 {lab=n4_ff.net8}
N 38120 710 38120 250 {lab=n4_ff.net8}
N 38320 710 38320 740 {lab=n4_ff.net8}
N 38120 250 38120 240 {lab=n4_ff.net8}
N 38120 250 38320 250 {lab=n4_ff.net8}
N 38320 250 38320 240 {lab=n4_ff.net8}
N 35510 710 35290 710 {lab=n4_ff.net8}
N 35510 710 35510 60 {lab=n4_ff.net8}
N 35290 710 35290 770 {lab=n4_ff.net8}
N 35290 770 35320 770 {lab=n4_ff.net8}
N 35510 60 35520 60 {lab=n4_ff.net8}
N 41440 740 41440 710 {lab=n5_ff.net8}
N 41440 710 41440 250 {lab=n5_ff.net8}
N 41440 710 38830 710 {lab=n5_ff.net8}
N 41440 710 41640 710 {lab=n5_ff.net8}
N 41640 710 41640 740 {lab=n5_ff.net8}
N 41440 250 41640 250 {lab=n5_ff.net8}
N 41440 250 41440 240 {lab=n5_ff.net8}
N 41640 250 41640 240 {lab=n5_ff.net8}
N 38830 710 38610 710 {lab=n5_ff.net8}
N 38830 710 38830 60 {lab=n5_ff.net8}
N 38610 710 38610 770 {lab=n5_ff.net8}
N 38610 770 38640 770 {lab=n5_ff.net8}
N 38830 60 38840 60 {lab=n5_ff.net8}
N 44760 740 44760 710 {lab=n6_ff.net8}
N 44760 710 44760 250 {lab=n6_ff.net8}
N 44760 710 44960 710 {lab=n6_ff.net8}
N 44760 710 42150 710 {lab=n6_ff.net8}
N 44960 710 44960 740 {lab=n6_ff.net8}
N 44760 250 44960 250 {lab=n6_ff.net8}
N 44760 250 44760 240 {lab=n6_ff.net8}
N 44960 250 44960 240 {lab=n6_ff.net8}
N 42150 710 42150 60 {lab=n6_ff.net8}
N 42150 710 41930 710 {lab=n6_ff.net8}
N 41930 710 41930 770 {lab=n6_ff.net8}
N 41930 770 41960 770 {lab=n6_ff.net8}
N 42150 60 42160 60 {lab=n6_ff.net8}
N 48080 740 48080 710 {lab=n7_ff.net8}
N 48080 710 48280 710 {lab=n7_ff.net8}
N 48080 710 45470 710 {lab=n7_ff.net8}
N 48080 710 48080 250 {lab=n7_ff.net8}
N 48280 710 48280 740 {lab=n7_ff.net8}
N 48080 250 48080 240 {lab=n7_ff.net8}
N 48080 250 48280 250 {lab=n7_ff.net8}
N 48280 250 48280 240 {lab=n7_ff.net8}
N 45470 710 45470 60 {lab=n7_ff.net8}
N 45470 710 45250 710 {lab=n7_ff.net8}
N 45250 710 45250 770 {lab=n7_ff.net8}
N 45250 770 45280 770 {lab=n7_ff.net8}
N 45470 60 45480 60 {lab=n7_ff.net8}
N 51400 740 51400 710 {lab=n8_ff.net8}
N 51400 710 51600 710 {lab=n8_ff.net8}
N 51400 710 48790 710 {lab=n8_ff.net8}
N 51400 710 51400 250 {lab=n8_ff.net8}
N 51600 710 51600 740 {lab=n8_ff.net8}
N 51400 250 51600 250 {lab=n8_ff.net8}
N 51400 250 51400 240 {lab=n8_ff.net8}
N 51600 250 51600 240 {lab=n8_ff.net8}
N 48790 710 48570 710 {lab=n8_ff.net8}
N 48790 710 48790 60 {lab=n8_ff.net8}
N 48570 710 48570 770 {lab=n8_ff.net8}
N 48570 770 48600 770 {lab=n8_ff.net8}
N 48790 60 48800 60 {lab=n8_ff.net8}
N 24840 740 24840 710 {lab=n16_ff.net8}
N 24840 710 24840 690 {lab=n16_ff.net8}
N 24840 710 25040 710 {lab=n16_ff.net8}
N 25040 710 25040 740 {lab=n16_ff.net8}
N 24840 690 22950 690 {lab=n16_ff.net8}
N 24840 690 24840 250 {lab=n16_ff.net8}
N 24840 250 24840 240 {lab=n16_ff.net8}
N 24840 250 25040 250 {lab=n16_ff.net8}
N 25040 250 25040 240 {lab=n16_ff.net8}
N 22950 690 22950 60 {lab=n16_ff.net8}
N 22950 690 22730 690 {lab=n16_ff.net8}
N 22730 690 22730 770 {lab=n16_ff.net8}
N 22730 770 22760 770 {lab=n16_ff.net8}
N 22950 60 22960 60 {lab=n16_ff.net8}
N 53240 890 53240 770 {lab=n10_ff.cki}
N 53240 770 53910 770 {lab=n10_ff.cki}
N 53240 770 53240 90 {lab=n10_ff.cki}
N 53910 770 53910 830 {lab=n10_ff.cki}
N 53910 770 53920 770 {lab=n10_ff.cki}
N 53910 830 54310 830 {lab=n10_ff.cki}
N 54310 830 54310 250 {lab=n10_ff.cki}
N 54310 830 54760 830 {lab=n10_ff.cki}
N 54760 830 54760 770 {lab=n10_ff.cki}
N 54760 770 54880 770 {lab=n10_ff.cki}
N 54310 250 54400 250 {lab=n10_ff.cki}
N 54310 250 54310 210 {lab=n10_ff.cki}
N 54310 210 54320 210 {lab=n10_ff.cki}
N 54400 250 54400 210 {lab=n10_ff.cki}
N 54400 210 54680 210 {lab=n10_ff.cki}
N 2840 920 2830 920 {lab=n_n_0}
N 2830 920 2830 1000 {lab=n_n_0}
N 2830 920 2810 920 {lab=n_n_0}
N 2830 1000 2110 1000 {lab=n_n_0}
N 2110 1000 2110 920 {lab=n_n_0}
N 2110 920 2120 920 {lab=n_n_0}
N 2110 920 2110 910 {lab=n_n_0}
N 2810 920 2810 110 {lab=n_n_0}
N 2810 110 2110 110 {lab=n_n_0}
N 2810 110 2810 60 {lab=n_n_0}
N 2810 60 2840 60 {lab=n_n_0}
N 2110 910 1810 910 {lab=n_n_0}
N 1810 910 1810 890 {lab=n_n_0}
N 1810 890 1800 890 {lab=n_n_0}
N 2110 110 2110 90 {lab=n_n_0}
N 2110 90 1800 90 {lab=n_n_0}
N 2110 90 2110 60 {lab=n_n_0}
N 2110 60 2120 60 {lab=n_n_0}
N 52840 920 52830 920 {lab=n_9}
N 52830 920 52830 860 {lab=n_9}
N 52830 920 52560 920 {lab=n_9}
N 52560 920 52560 890 {lab=n_9}
N 52560 890 52520 890 {lab=n_9}
N 52830 860 52830 110 {lab=n_9}
N 52830 860 53280 860 {lab=n_9}
N 53280 860 53280 920 {lab=n_9}
N 53280 920 53560 920 {lab=n_9}
N 52830 110 53280 110 {lab=n_9}
N 52830 110 52830 90 {lab=n_9}
N 52830 90 52520 90 {lab=n_9}
N 52830 90 52830 60 {lab=n_9}
N 52830 60 52840 60 {lab=n_9}
N 53280 110 53280 60 {lab=n_9}
N 53280 60 53560 60 {lab=n_9}
N 2880 740 2880 580 {lab=n0_ff.net1}
N 2880 580 2880 240 {lab=n0_ff.net1}
N 2880 580 3080 580 {lab=n0_ff.net1}
N 3080 580 3080 590 {lab=n0_ff.net1}
N 3080 590 3160 590 {lab=n0_ff.net1}
N 3160 590 3280 590 {lab=n0_ff.net1}
N 3160 590 3160 920 {lab=n0_ff.net1}
N 3160 920 3600 920 {lab=n0_ff.net1}
N 3280 590 3280 270 {lab=n0_ff.net1}
N 3280 270 3280 240 {lab=n0_ff.net1}
N 3280 270 3340 270 {lab=n0_ff.net1}
N 3340 270 3340 60 {lab=n0_ff.net1}
N 3340 60 3600 60 {lab=n0_ff.net1}
N 53960 740 53960 580 {lab=n10_ff.net1}
N 53960 580 54160 580 {lab=n10_ff.net1}
N 53960 580 53960 240 {lab=n10_ff.net1}
N 54160 580 54160 590 {lab=n10_ff.net1}
N 54160 590 54240 590 {lab=n10_ff.net1}
N 54240 590 54240 920 {lab=n10_ff.net1}
N 54240 590 54360 590 {lab=n10_ff.net1}
N 54240 920 54680 920 {lab=n10_ff.net1}
N 54360 590 54360 270 {lab=n10_ff.net1}
N 54360 270 54420 270 {lab=n10_ff.net1}
N 54360 270 54360 240 {lab=n10_ff.net1}
N 54420 270 54420 60 {lab=n10_ff.net1}
N 54420 60 54680 60 {lab=n10_ff.net1}
N 8200 740 8200 580 {lab=n11_ff.net1}
N 8200 580 8200 240 {lab=n11_ff.net1}
N 8200 580 8400 580 {lab=n11_ff.net1}
N 8400 580 8400 590 {lab=n11_ff.net1}
N 8400 590 8480 590 {lab=n11_ff.net1}
N 8480 590 8600 590 {lab=n11_ff.net1}
N 8480 590 8480 920 {lab=n11_ff.net1}
N 8480 920 8920 920 {lab=n11_ff.net1}
N 8600 590 8600 270 {lab=n11_ff.net1}
N 8600 270 8600 240 {lab=n11_ff.net1}
N 8600 270 8660 270 {lab=n11_ff.net1}
N 8660 270 8660 60 {lab=n11_ff.net1}
N 8660 60 8920 60 {lab=n11_ff.net1}
N 11520 740 11520 580 {lab=n12_ff.net1}
N 11520 580 11520 240 {lab=n12_ff.net1}
N 11520 580 11720 580 {lab=n12_ff.net1}
N 11720 580 11720 590 {lab=n12_ff.net1}
N 11720 590 11800 590 {lab=n12_ff.net1}
N 11800 590 11800 920 {lab=n12_ff.net1}
N 11800 590 11920 590 {lab=n12_ff.net1}
N 11800 920 12240 920 {lab=n12_ff.net1}
N 11920 590 11920 270 {lab=n12_ff.net1}
N 11920 270 11980 270 {lab=n12_ff.net1}
N 11920 270 11920 240 {lab=n12_ff.net1}
N 11980 270 11980 60 {lab=n12_ff.net1}
N 11980 60 12240 60 {lab=n12_ff.net1}
N 14840 740 14840 580 {lab=n13_ff.net1}
N 14840 580 15040 580 {lab=n13_ff.net1}
N 14840 580 14840 240 {lab=n13_ff.net1}
N 15040 580 15040 590 {lab=n13_ff.net1}
N 15040 590 15120 590 {lab=n13_ff.net1}
N 15120 590 15120 920 {lab=n13_ff.net1}
N 15120 590 15240 590 {lab=n13_ff.net1}
N 15120 920 15560 920 {lab=n13_ff.net1}
N 15240 590 15240 270 {lab=n13_ff.net1}
N 15240 270 15300 270 {lab=n13_ff.net1}
N 15240 270 15240 240 {lab=n13_ff.net1}
N 15300 270 15300 60 {lab=n13_ff.net1}
N 15300 60 15560 60 {lab=n13_ff.net1}
N 18160 740 18160 580 {lab=n14_ff.net1}
N 18160 580 18360 580 {lab=n14_ff.net1}
N 18160 580 18160 240 {lab=n14_ff.net1}
N 18360 580 18360 590 {lab=n14_ff.net1}
N 18360 590 18440 590 {lab=n14_ff.net1}
N 18440 590 18440 920 {lab=n14_ff.net1}
N 18440 590 18560 590 {lab=n14_ff.net1}
N 18440 920 18880 920 {lab=n14_ff.net1}
N 18560 590 18560 270 {lab=n14_ff.net1}
N 18560 270 18560 240 {lab=n14_ff.net1}
N 18560 270 18620 270 {lab=n14_ff.net1}
N 18620 270 18620 60 {lab=n14_ff.net1}
N 18620 60 18880 60 {lab=n14_ff.net1}
N 21480 740 21480 580 {lab=n15_ff.net1}
N 21480 580 21480 240 {lab=n15_ff.net1}
N 21480 580 21680 580 {lab=n15_ff.net1}
N 21680 580 21680 590 {lab=n15_ff.net1}
N 21680 590 21760 590 {lab=n15_ff.net1}
N 21760 590 21760 920 {lab=n15_ff.net1}
N 21760 590 21880 590 {lab=n15_ff.net1}
N 21760 920 22200 920 {lab=n15_ff.net1}
N 21880 590 21880 270 {lab=n15_ff.net1}
N 21880 270 21940 270 {lab=n15_ff.net1}
N 21880 270 21880 240 {lab=n15_ff.net1}
N 21940 270 21940 60 {lab=n15_ff.net1}
N 21940 60 22200 60 {lab=n15_ff.net1}
N 24080 740 24080 580 {lab=n16_ff.net1}
N 24080 580 24280 580 {lab=n16_ff.net1}
N 24080 580 24080 240 {lab=n16_ff.net1}
N 24280 580 24280 590 {lab=n16_ff.net1}
N 24280 590 24360 590 {lab=n16_ff.net1}
N 24360 590 24480 590 {lab=n16_ff.net1}
N 24360 590 24360 920 {lab=n16_ff.net1}
N 24360 920 24800 920 {lab=n16_ff.net1}
N 24480 590 24480 270 {lab=n16_ff.net1}
N 24480 270 24480 240 {lab=n16_ff.net1}
N 24480 270 24540 270 {lab=n16_ff.net1}
N 24540 270 24540 60 {lab=n16_ff.net1}
N 24540 60 24800 60 {lab=n16_ff.net1}
N 27400 740 27400 580 {lab=n1_ff.net1}
N 27400 580 27400 240 {lab=n1_ff.net1}
N 27400 580 27600 580 {lab=n1_ff.net1}
N 27600 580 27600 590 {lab=n1_ff.net1}
N 27600 590 27680 590 {lab=n1_ff.net1}
N 27680 590 27680 920 {lab=n1_ff.net1}
N 27680 590 27800 590 {lab=n1_ff.net1}
N 27680 920 28120 920 {lab=n1_ff.net1}
N 27800 590 27800 270 {lab=n1_ff.net1}
N 27800 270 27860 270 {lab=n1_ff.net1}
N 27800 270 27800 240 {lab=n1_ff.net1}
N 27860 270 27860 60 {lab=n1_ff.net1}
N 27860 60 28120 60 {lab=n1_ff.net1}
N 30720 740 30720 580 {lab=n2_ff.net1}
N 30720 580 30920 580 {lab=n2_ff.net1}
N 30720 580 30720 240 {lab=n2_ff.net1}
N 30920 580 30920 590 {lab=n2_ff.net1}
N 30920 590 31000 590 {lab=n2_ff.net1}
N 31000 590 31000 920 {lab=n2_ff.net1}
N 31000 590 31120 590 {lab=n2_ff.net1}
N 31000 920 31440 920 {lab=n2_ff.net1}
N 31120 590 31120 270 {lab=n2_ff.net1}
N 31120 270 31180 270 {lab=n2_ff.net1}
N 31120 270 31120 240 {lab=n2_ff.net1}
N 31180 270 31180 60 {lab=n2_ff.net1}
N 31180 60 31440 60 {lab=n2_ff.net1}
N 34040 740 34040 580 {lab=n3_ff.net1}
N 34040 580 34240 580 {lab=n3_ff.net1}
N 34040 580 34040 240 {lab=n3_ff.net1}
N 34240 580 34240 590 {lab=n3_ff.net1}
N 34240 590 34320 590 {lab=n3_ff.net1}
N 34320 590 34320 920 {lab=n3_ff.net1}
N 34320 590 34440 590 {lab=n3_ff.net1}
N 34320 920 34760 920 {lab=n3_ff.net1}
N 34440 590 34440 270 {lab=n3_ff.net1}
N 34440 270 34440 240 {lab=n3_ff.net1}
N 34440 270 34500 270 {lab=n3_ff.net1}
N 34500 270 34500 60 {lab=n3_ff.net1}
N 34500 60 34760 60 {lab=n3_ff.net1}
N 37360 740 37360 580 {lab=n4_ff.net1}
N 37360 580 37360 240 {lab=n4_ff.net1}
N 37360 580 37560 580 {lab=n4_ff.net1}
N 37560 580 37560 590 {lab=n4_ff.net1}
N 37560 590 37640 590 {lab=n4_ff.net1}
N 37640 590 37760 590 {lab=n4_ff.net1}
N 37640 590 37640 920 {lab=n4_ff.net1}
N 37640 920 38080 920 {lab=n4_ff.net1}
N 37760 590 37760 270 {lab=n4_ff.net1}
N 37760 270 37820 270 {lab=n4_ff.net1}
N 37760 270 37760 240 {lab=n4_ff.net1}
N 37820 270 37820 60 {lab=n4_ff.net1}
N 37820 60 38080 60 {lab=n4_ff.net1}
N 40680 740 40680 580 {lab=n5_ff.net1}
N 40680 580 40880 580 {lab=n5_ff.net1}
N 40680 580 40680 240 {lab=n5_ff.net1}
N 40880 580 40880 590 {lab=n5_ff.net1}
N 40880 590 40960 590 {lab=n5_ff.net1}
N 40960 590 40960 920 {lab=n5_ff.net1}
N 40960 590 41080 590 {lab=n5_ff.net1}
N 40960 920 41400 920 {lab=n5_ff.net1}
N 41080 590 41080 270 {lab=n5_ff.net1}
N 41080 270 41140 270 {lab=n5_ff.net1}
N 41080 270 41080 240 {lab=n5_ff.net1}
N 41140 270 41140 60 {lab=n5_ff.net1}
N 41140 60 41400 60 {lab=n5_ff.net1}
N 44000 740 44000 580 {lab=n6_ff.net1}
N 44000 580 44200 580 {lab=n6_ff.net1}
N 44000 580 44000 240 {lab=n6_ff.net1}
N 44200 580 44200 590 {lab=n6_ff.net1}
N 44200 590 44280 590 {lab=n6_ff.net1}
N 44280 590 44280 920 {lab=n6_ff.net1}
N 44280 590 44400 590 {lab=n6_ff.net1}
N 44280 920 44720 920 {lab=n6_ff.net1}
N 44400 590 44400 270 {lab=n6_ff.net1}
N 44400 270 44400 240 {lab=n6_ff.net1}
N 44400 270 44460 270 {lab=n6_ff.net1}
N 44460 270 44460 60 {lab=n6_ff.net1}
N 44460 60 44720 60 {lab=n6_ff.net1}
N 47320 740 47320 580 {lab=n7_ff.net1}
N 47320 580 47320 240 {lab=n7_ff.net1}
N 47320 580 47520 580 {lab=n7_ff.net1}
N 47520 580 47520 590 {lab=n7_ff.net1}
N 47520 590 47600 590 {lab=n7_ff.net1}
N 47600 590 47720 590 {lab=n7_ff.net1}
N 47600 590 47600 920 {lab=n7_ff.net1}
N 47600 920 48040 920 {lab=n7_ff.net1}
N 47720 590 47720 270 {lab=n7_ff.net1}
N 47720 270 47720 240 {lab=n7_ff.net1}
N 47720 270 47780 270 {lab=n7_ff.net1}
N 47780 270 47780 60 {lab=n7_ff.net1}
N 47780 60 48040 60 {lab=n7_ff.net1}
N 50640 740 50640 580 {lab=n8_ff.net1}
N 50640 580 50640 240 {lab=n8_ff.net1}
N 50640 580 50840 580 {lab=n8_ff.net1}
N 50840 580 50840 590 {lab=n8_ff.net1}
N 50840 590 50920 590 {lab=n8_ff.net1}
N 50920 590 50920 920 {lab=n8_ff.net1}
N 50920 590 51040 590 {lab=n8_ff.net1}
N 50920 920 51360 920 {lab=n8_ff.net1}
N 51040 590 51040 270 {lab=n8_ff.net1}
N 51040 270 51100 270 {lab=n8_ff.net1}
N 51040 270 51040 240 {lab=n8_ff.net1}
N 51100 270 51100 60 {lab=n8_ff.net1}
N 51100 60 51360 60 {lab=n8_ff.net1}
N 55280 740 55280 580 {lab=n9_ff.net1}
N 55280 580 55280 240 {lab=n9_ff.net1}
N 55280 580 55480 580 {lab=n9_ff.net1}
N 55480 580 55480 590 {lab=n9_ff.net1}
N 55480 590 55560 590 {lab=n9_ff.net1}
N 55560 590 55680 590 {lab=n9_ff.net1}
N 55560 590 55560 920 {lab=n9_ff.net1}
N 55560 920 56000 920 {lab=n9_ff.net1}
N 55680 590 55680 270 {lab=n9_ff.net1}
N 55680 270 55680 240 {lab=n9_ff.net1}
N 55680 270 55740 270 {lab=n9_ff.net1}
N 55740 270 55740 60 {lab=n9_ff.net1}
N 55740 60 56000 60 {lab=n9_ff.net1}
N 4760 890 4800 890 {lab=n_10}
N 4760 890 4760 90 {lab=n_10}
N 4800 890 4800 920 {lab=n_10}
N 4800 920 5070 920 {lab=n_10}
N 5070 920 5080 920 {lab=n_10}
N 5070 920 5070 860 {lab=n_10}
N 5070 860 5160 860 {lab=n_10}
N 5160 860 5160 920 {lab=n_10}
N 5160 920 5440 920 {lab=n_10}
N 4760 90 4800 90 {lab=n_10}
N 4800 90 4800 60 {lab=n_10}
N 4800 60 5070 60 {lab=n_10}
N 5070 60 5080 60 {lab=n_10}
N 5070 60 5070 100 {lab=n_10}
N 5070 100 5160 100 {lab=n_10}
N 5160 100 5160 60 {lab=n_10}
N 5160 60 5440 60 {lab=n_10}
N 6760 890 6800 890 {lab=n_11}
N 6760 890 6760 90 {lab=n_11}
N 6800 890 6800 920 {lab=n_11}
N 6800 920 7070 920 {lab=n_11}
N 7070 920 7070 840 {lab=n_11}
N 7070 920 7080 920 {lab=n_11}
N 7070 840 7160 840 {lab=n_11}
N 7160 840 7160 920 {lab=n_11}
N 7160 920 7440 920 {lab=n_11}
N 6760 90 6800 90 {lab=n_11}
N 6800 90 6800 60 {lab=n_11}
N 6800 60 7070 60 {lab=n_11}
N 7070 60 7080 60 {lab=n_11}
N 7070 60 7070 100 {lab=n_11}
N 7070 100 7160 100 {lab=n_11}
N 7160 100 7160 60 {lab=n_11}
N 7160 60 7440 60 {lab=n_11}
N 10080 890 10120 890 {lab=n_12}
N 10080 890 10080 90 {lab=n_12}
N 10120 890 10120 920 {lab=n_12}
N 10120 920 10390 920 {lab=n_12}
N 10390 920 10400 920 {lab=n_12}
N 10390 920 10390 860 {lab=n_12}
N 10390 860 10480 860 {lab=n_12}
N 10480 860 10480 920 {lab=n_12}
N 10480 920 10760 920 {lab=n_12}
N 10080 90 10120 90 {lab=n_12}
N 10120 90 10120 60 {lab=n_12}
N 10120 60 10390 60 {lab=n_12}
N 10390 60 10400 60 {lab=n_12}
N 10390 60 10390 100 {lab=n_12}
N 10390 100 10480 100 {lab=n_12}
N 10480 100 10480 60 {lab=n_12}
N 10480 60 10760 60 {lab=n_12}
N 13400 890 13400 90 {lab=n_13}
N 13400 890 13440 890 {lab=n_13}
N 13440 890 13440 920 {lab=n_13}
N 13440 920 13710 920 {lab=n_13}
N 13710 920 13710 860 {lab=n_13}
N 13710 920 13720 920 {lab=n_13}
N 13710 860 13800 860 {lab=n_13}
N 13800 860 13800 920 {lab=n_13}
N 13800 920 14080 920 {lab=n_13}
N 13400 90 13440 90 {lab=n_13}
N 13440 90 13440 60 {lab=n_13}
N 13440 60 13710 60 {lab=n_13}
N 13710 60 13710 100 {lab=n_13}
N 13710 60 13720 60 {lab=n_13}
N 13710 100 13800 100 {lab=n_13}
N 13800 100 13800 60 {lab=n_13}
N 13800 60 14080 60 {lab=n_13}
N 16720 890 16720 90 {lab=n_14}
N 16720 890 16760 890 {lab=n_14}
N 16760 890 16760 920 {lab=n_14}
N 16760 920 17030 920 {lab=n_14}
N 17030 920 17030 860 {lab=n_14}
N 17030 920 17040 920 {lab=n_14}
N 17030 860 17120 860 {lab=n_14}
N 17120 860 17120 920 {lab=n_14}
N 17120 920 17400 920 {lab=n_14}
N 16720 90 16760 90 {lab=n_14}
N 16760 90 16760 60 {lab=n_14}
N 16760 60 17030 60 {lab=n_14}
N 17030 60 17030 100 {lab=n_14}
N 17030 60 17040 60 {lab=n_14}
N 17030 100 17120 100 {lab=n_14}
N 17120 100 17120 60 {lab=n_14}
N 17120 60 17400 60 {lab=n_14}
N 20040 890 20080 890 {lab=n_15}
N 20040 890 20040 90 {lab=n_15}
N 20080 890 20080 920 {lab=n_15}
N 20080 920 20350 920 {lab=n_15}
N 20350 920 20360 920 {lab=n_15}
N 20350 920 20350 860 {lab=n_15}
N 20350 860 20440 860 {lab=n_15}
N 20440 860 20440 920 {lab=n_15}
N 20440 920 20720 920 {lab=n_15}
N 20040 90 20080 90 {lab=n_15}
N 20080 90 20080 60 {lab=n_15}
N 20080 60 20350 60 {lab=n_15}
N 20350 60 20350 100 {lab=n_15}
N 20350 60 20360 60 {lab=n_15}
N 20350 100 20440 100 {lab=n_15}
N 20440 100 20440 60 {lab=n_15}
N 20440 60 20720 60 {lab=n_15}
N 25960 890 26000 890 {lab=n_1}
N 25960 890 25960 90 {lab=n_1}
N 26000 890 26000 920 {lab=n_1}
N 26000 920 26270 920 {lab=n_1}
N 26270 920 26280 920 {lab=n_1}
N 26270 920 26270 860 {lab=n_1}
N 26270 860 26360 860 {lab=n_1}
N 26360 860 26360 920 {lab=n_1}
N 26360 920 26640 920 {lab=n_1}
N 25960 90 26000 90 {lab=n_1}
N 26000 90 26000 60 {lab=n_1}
N 26000 60 26270 60 {lab=n_1}
N 26270 60 26280 60 {lab=n_1}
N 26270 60 26270 100 {lab=n_1}
N 26270 100 26360 100 {lab=n_1}
N 26360 100 26360 60 {lab=n_1}
N 26360 60 26640 60 {lab=n_1}
N 29280 890 29280 90 {lab=n_2}
N 29280 890 29320 890 {lab=n_2}
N 29320 890 29320 920 {lab=n_2}
N 29320 920 29590 920 {lab=n_2}
N 29590 920 29600 920 {lab=n_2}
N 29590 920 29590 860 {lab=n_2}
N 29590 860 29680 860 {lab=n_2}
N 29680 860 29680 920 {lab=n_2}
N 29680 920 29960 920 {lab=n_2}
N 29280 90 29320 90 {lab=n_2}
N 29320 90 29320 60 {lab=n_2}
N 29320 60 29590 60 {lab=n_2}
N 29590 60 29590 100 {lab=n_2}
N 29590 60 29600 60 {lab=n_2}
N 29590 100 29680 100 {lab=n_2}
N 29680 100 29680 60 {lab=n_2}
N 29680 60 29960 60 {lab=n_2}
N 32600 890 32600 90 {lab=n_3}
N 32600 890 32640 890 {lab=n_3}
N 32640 890 32640 920 {lab=n_3}
N 32640 920 32910 920 {lab=n_3}
N 32910 920 32910 860 {lab=n_3}
N 32910 920 32920 920 {lab=n_3}
N 32910 860 33000 860 {lab=n_3}
N 33000 860 33000 920 {lab=n_3}
N 33000 920 33280 920 {lab=n_3}
N 32600 90 32640 90 {lab=n_3}
N 32640 90 32640 60 {lab=n_3}
N 32640 60 32910 60 {lab=n_3}
N 32910 60 32910 100 {lab=n_3}
N 32910 60 32920 60 {lab=n_3}
N 32910 100 33000 100 {lab=n_3}
N 33000 100 33000 60 {lab=n_3}
N 33000 60 33280 60 {lab=n_3}
N 35920 890 35960 890 {lab=n_4}
N 35920 890 35920 90 {lab=n_4}
N 35960 890 35960 920 {lab=n_4}
N 35960 920 36230 920 {lab=n_4}
N 36230 920 36240 920 {lab=n_4}
N 36230 920 36230 860 {lab=n_4}
N 36230 860 36320 860 {lab=n_4}
N 36320 860 36320 920 {lab=n_4}
N 36320 920 36600 920 {lab=n_4}
N 35920 90 35960 90 {lab=n_4}
N 35960 90 35960 60 {lab=n_4}
N 35960 60 36230 60 {lab=n_4}
N 36230 60 36230 100 {lab=n_4}
N 36230 60 36240 60 {lab=n_4}
N 36230 100 36320 100 {lab=n_4}
N 36320 100 36320 60 {lab=n_4}
N 36320 60 36600 60 {lab=n_4}
N 39240 890 39280 890 {lab=n_5}
N 39240 890 39240 90 {lab=n_5}
N 39280 890 39280 920 {lab=n_5}
N 39280 920 39550 920 {lab=n_5}
N 39550 920 39560 920 {lab=n_5}
N 39550 920 39550 860 {lab=n_5}
N 39550 860 39640 860 {lab=n_5}
N 39640 860 39640 920 {lab=n_5}
N 39640 920 39920 920 {lab=n_5}
N 39240 90 39280 90 {lab=n_5}
N 39280 90 39280 60 {lab=n_5}
N 39280 60 39550 60 {lab=n_5}
N 39550 60 39560 60 {lab=n_5}
N 39550 60 39550 100 {lab=n_5}
N 39550 100 39640 100 {lab=n_5}
N 39640 100 39640 60 {lab=n_5}
N 39640 60 39920 60 {lab=n_5}
N 42560 890 42560 90 {lab=n_6}
N 42560 890 42600 890 {lab=n_6}
N 42600 890 42600 920 {lab=n_6}
N 42600 920 42870 920 {lab=n_6}
N 42870 920 42870 860 {lab=n_6}
N 42870 920 42880 920 {lab=n_6}
N 42870 860 42960 860 {lab=n_6}
N 42960 860 42960 920 {lab=n_6}
N 42960 920 43240 920 {lab=n_6}
N 42560 90 42600 90 {lab=n_6}
N 42600 90 42600 60 {lab=n_6}
N 42600 60 42870 60 {lab=n_6}
N 42870 60 42870 100 {lab=n_6}
N 42870 60 42880 60 {lab=n_6}
N 42870 100 42960 100 {lab=n_6}
N 42960 100 42960 60 {lab=n_6}
N 42960 60 43240 60 {lab=n_6}
N 45880 890 45920 890 {lab=n_7}
N 45880 890 45880 90 {lab=n_7}
N 45920 890 45920 920 {lab=n_7}
N 45920 920 46190 920 {lab=n_7}
N 46190 920 46200 920 {lab=n_7}
N 46190 920 46190 860 {lab=n_7}
N 46190 860 46280 860 {lab=n_7}
N 46280 860 46280 920 {lab=n_7}
N 46280 920 46560 920 {lab=n_7}
N 45880 90 45920 90 {lab=n_7}
N 45920 90 45920 60 {lab=n_7}
N 45920 60 46190 60 {lab=n_7}
N 46190 60 46190 100 {lab=n_7}
N 46190 60 46200 60 {lab=n_7}
N 46190 100 46280 100 {lab=n_7}
N 46280 100 46280 60 {lab=n_7}
N 46280 60 46560 60 {lab=n_7}
N 49200 890 49240 890 {lab=n_8}
N 49200 890 49200 90 {lab=n_8}
N 49240 890 49240 920 {lab=n_8}
N 49240 920 49510 920 {lab=n_8}
N 49510 920 49520 920 {lab=n_8}
N 49510 920 49510 860 {lab=n_8}
N 49510 860 49600 860 {lab=n_8}
N 49600 860 49600 920 {lab=n_8}
N 49600 920 49880 920 {lab=n_8}
N 49200 90 49240 90 {lab=n_8}
N 49240 90 49240 60 {lab=n_8}
N 49240 60 49510 60 {lab=n_8}
N 49510 60 49510 100 {lab=n_8}
N 49510 60 49520 60 {lab=n_8}
N 49510 100 49600 100 {lab=n_8}
N 49600 100 49600 60 {lab=n_8}
N 49600 60 49880 60 {lab=n_8}
N 3040 770 3030 770 {lab=n0_ff.net2}
N 3030 770 3030 830 {lab=n0_ff.net2}
N 3030 770 3010 770 {lab=n0_ff.net2}
N 3030 830 3640 830 {lab=n0_ff.net2}
N 3640 830 3640 800 {lab=n0_ff.net2}
N 3640 830 3640 890 {lab=n0_ff.net2}
N 3010 770 3010 170 {lab=n0_ff.net2}
N 3010 170 3640 170 {lab=n0_ff.net2}
N 3010 170 3010 60 {lab=n0_ff.net2}
N 3010 60 3040 60 {lab=n0_ff.net2}
N 3640 170 3640 180 {lab=n0_ff.net2}
N 3640 170 3640 90 {lab=n0_ff.net2}
N 54120 770 54110 770 {lab=n10_ff.net2}
N 54110 770 54090 770 {lab=n10_ff.net2}
N 54110 770 54110 850 {lab=n10_ff.net2}
N 54110 850 54720 850 {lab=n10_ff.net2}
N 54720 850 54720 800 {lab=n10_ff.net2}
N 54720 850 54720 890 {lab=n10_ff.net2}
N 54090 770 54090 170 {lab=n10_ff.net2}
N 54090 170 54720 170 {lab=n10_ff.net2}
N 54090 170 54090 60 {lab=n10_ff.net2}
N 54090 60 54120 60 {lab=n10_ff.net2}
N 54720 170 54720 90 {lab=n10_ff.net2}
N 54720 170 54720 180 {lab=n10_ff.net2}
N 8360 770 8350 770 {lab=n11_ff.net2}
N 8350 770 8350 730 {lab=n11_ff.net2}
N 8350 730 8330 730 {lab=n11_ff.net2}
N 8350 730 8890 730 {lab=n11_ff.net2}
N 8890 730 8890 840 {lab=n11_ff.net2}
N 8890 840 8960 840 {lab=n11_ff.net2}
N 8960 840 8960 800 {lab=n11_ff.net2}
N 8960 840 8960 890 {lab=n11_ff.net2}
N 8330 730 8330 170 {lab=n11_ff.net2}
N 8330 170 8960 170 {lab=n11_ff.net2}
N 8330 170 8330 60 {lab=n11_ff.net2}
N 8330 60 8360 60 {lab=n11_ff.net2}
N 8960 170 8960 180 {lab=n11_ff.net2}
N 8960 170 8960 90 {lab=n11_ff.net2}
N 11680 770 11670 770 {lab=n12_ff.net2}
N 11670 770 11670 730 {lab=n12_ff.net2}
N 11670 730 12210 730 {lab=n12_ff.net2}
N 11670 730 11650 730 {lab=n12_ff.net2}
N 12210 730 12210 820 {lab=n12_ff.net2}
N 12210 820 12280 820 {lab=n12_ff.net2}
N 12280 820 12280 890 {lab=n12_ff.net2}
N 12280 820 12280 800 {lab=n12_ff.net2}
N 11650 730 11650 170 {lab=n12_ff.net2}
N 11650 170 12280 170 {lab=n12_ff.net2}
N 11650 170 11650 60 {lab=n12_ff.net2}
N 11650 60 11680 60 {lab=n12_ff.net2}
N 12280 170 12280 90 {lab=n12_ff.net2}
N 12280 170 12280 180 {lab=n12_ff.net2}
N 15000 770 14990 770 {lab=n13_ff.net2}
N 14990 770 14990 730 {lab=n13_ff.net2}
N 14990 730 15530 730 {lab=n13_ff.net2}
N 14990 730 14970 730 {lab=n13_ff.net2}
N 15530 730 15530 820 {lab=n13_ff.net2}
N 15530 820 15600 820 {lab=n13_ff.net2}
N 15600 820 15600 890 {lab=n13_ff.net2}
N 15600 820 15600 800 {lab=n13_ff.net2}
N 14970 730 14970 170 {lab=n13_ff.net2}
N 14970 170 14970 60 {lab=n13_ff.net2}
N 14970 170 15600 170 {lab=n13_ff.net2}
N 14970 60 15000 60 {lab=n13_ff.net2}
N 15600 170 15600 180 {lab=n13_ff.net2}
N 15600 170 15600 90 {lab=n13_ff.net2}
N 18320 770 18310 770 {lab=n14_ff.net2}
N 18310 770 18310 730 {lab=n14_ff.net2}
N 18310 730 18850 730 {lab=n14_ff.net2}
N 18310 730 18290 730 {lab=n14_ff.net2}
N 18850 730 18850 820 {lab=n14_ff.net2}
N 18850 820 18920 820 {lab=n14_ff.net2}
N 18920 820 18920 800 {lab=n14_ff.net2}
N 18920 820 18920 890 {lab=n14_ff.net2}
N 18290 730 18290 170 {lab=n14_ff.net2}
N 18290 170 18920 170 {lab=n14_ff.net2}
N 18290 170 18290 60 {lab=n14_ff.net2}
N 18290 60 18320 60 {lab=n14_ff.net2}
N 18920 170 18920 180 {lab=n14_ff.net2}
N 18920 170 18920 90 {lab=n14_ff.net2}
N 21640 770 21630 770 {lab=n15_ff.net2}
N 21630 770 21630 730 {lab=n15_ff.net2}
N 21630 730 22170 730 {lab=n15_ff.net2}
N 21630 730 21610 730 {lab=n15_ff.net2}
N 22170 730 22170 820 {lab=n15_ff.net2}
N 22170 820 22240 820 {lab=n15_ff.net2}
N 22240 820 22240 800 {lab=n15_ff.net2}
N 22240 820 22240 890 {lab=n15_ff.net2}
N 21610 730 21610 170 {lab=n15_ff.net2}
N 21610 170 22240 170 {lab=n15_ff.net2}
N 21610 170 21610 60 {lab=n15_ff.net2}
N 21610 60 21640 60 {lab=n15_ff.net2}
N 22240 170 22240 180 {lab=n15_ff.net2}
N 22240 170 22240 90 {lab=n15_ff.net2}
N 24240 770 24230 770 {lab=n16_ff.net2}
N 24230 770 24230 830 {lab=n16_ff.net2}
N 24230 770 24210 770 {lab=n16_ff.net2}
N 24230 830 24840 830 {lab=n16_ff.net2}
N 24840 830 24840 800 {lab=n16_ff.net2}
N 24840 830 24840 890 {lab=n16_ff.net2}
N 24210 770 24210 170 {lab=n16_ff.net2}
N 24210 170 24840 170 {lab=n16_ff.net2}
N 24210 170 24210 60 {lab=n16_ff.net2}
N 24210 60 24240 60 {lab=n16_ff.net2}
N 24840 170 24840 180 {lab=n16_ff.net2}
N 24840 170 24840 90 {lab=n16_ff.net2}
N 27560 770 27550 770 {lab=n1_ff.net2}
N 27550 770 27550 730 {lab=n1_ff.net2}
N 27550 730 28090 730 {lab=n1_ff.net2}
N 27550 730 27530 730 {lab=n1_ff.net2}
N 28090 730 28090 840 {lab=n1_ff.net2}
N 28090 840 28160 840 {lab=n1_ff.net2}
N 28160 840 28160 890 {lab=n1_ff.net2}
N 28160 840 28160 800 {lab=n1_ff.net2}
N 27530 730 27530 170 {lab=n1_ff.net2}
N 27530 170 28160 170 {lab=n1_ff.net2}
N 27530 170 27530 60 {lab=n1_ff.net2}
N 27530 60 27560 60 {lab=n1_ff.net2}
N 28160 170 28160 90 {lab=n1_ff.net2}
N 28160 170 28160 180 {lab=n1_ff.net2}
N 30880 770 30870 770 {lab=n2_ff.net2}
N 30870 770 30870 730 {lab=n2_ff.net2}
N 30870 730 31410 730 {lab=n2_ff.net2}
N 30870 730 30850 730 {lab=n2_ff.net2}
N 31410 730 31410 840 {lab=n2_ff.net2}
N 31410 840 31480 840 {lab=n2_ff.net2}
N 31480 840 31480 800 {lab=n2_ff.net2}
N 31480 840 31480 890 {lab=n2_ff.net2}
N 30850 730 30850 170 {lab=n2_ff.net2}
N 30850 170 30850 60 {lab=n2_ff.net2}
N 30850 170 31480 170 {lab=n2_ff.net2}
N 30850 60 30880 60 {lab=n2_ff.net2}
N 31480 170 31480 90 {lab=n2_ff.net2}
N 31480 170 31480 180 {lab=n2_ff.net2}
N 34200 770 34190 770 {lab=n3_ff.net2}
N 34190 770 34190 730 {lab=n3_ff.net2}
N 34190 730 34730 730 {lab=n3_ff.net2}
N 34190 730 34170 730 {lab=n3_ff.net2}
N 34730 730 34730 840 {lab=n3_ff.net2}
N 34730 840 34800 840 {lab=n3_ff.net2}
N 34800 840 34800 800 {lab=n3_ff.net2}
N 34800 840 34800 890 {lab=n3_ff.net2}
N 34170 730 34170 170 {lab=n3_ff.net2}
N 34170 170 34170 60 {lab=n3_ff.net2}
N 34170 170 34800 170 {lab=n3_ff.net2}
N 34170 60 34200 60 {lab=n3_ff.net2}
N 34800 170 34800 180 {lab=n3_ff.net2}
N 34800 170 34800 90 {lab=n3_ff.net2}
N 37520 770 37510 770 {lab=n4_ff.net2}
N 37510 770 37510 730 {lab=n4_ff.net2}
N 37510 730 37490 730 {lab=n4_ff.net2}
N 37510 730 38050 730 {lab=n4_ff.net2}
N 38050 730 38050 840 {lab=n4_ff.net2}
N 38050 840 38120 840 {lab=n4_ff.net2}
N 38120 840 38120 890 {lab=n4_ff.net2}
N 38120 840 38120 800 {lab=n4_ff.net2}
N 37490 730 37490 170 {lab=n4_ff.net2}
N 37490 170 38120 170 {lab=n4_ff.net2}
N 37490 170 37490 60 {lab=n4_ff.net2}
N 37490 60 37520 60 {lab=n4_ff.net2}
N 38120 170 38120 180 {lab=n4_ff.net2}
N 38120 170 38120 90 {lab=n4_ff.net2}
N 40840 770 40830 770 {lab=n5_ff.net2}
N 40830 770 40830 730 {lab=n5_ff.net2}
N 40830 730 41370 730 {lab=n5_ff.net2}
N 40830 730 40810 730 {lab=n5_ff.net2}
N 41370 730 41370 840 {lab=n5_ff.net2}
N 41370 840 41440 840 {lab=n5_ff.net2}
N 41440 840 41440 800 {lab=n5_ff.net2}
N 41440 840 41440 890 {lab=n5_ff.net2}
N 40810 730 40810 170 {lab=n5_ff.net2}
N 40810 170 41440 170 {lab=n5_ff.net2}
N 40810 170 40810 60 {lab=n5_ff.net2}
N 40810 60 40840 60 {lab=n5_ff.net2}
N 41440 170 41440 90 {lab=n5_ff.net2}
N 41440 170 41440 180 {lab=n5_ff.net2}
N 44160 770 44150 770 {lab=n6_ff.net2}
N 44150 770 44150 730 {lab=n6_ff.net2}
N 44150 730 44690 730 {lab=n6_ff.net2}
N 44150 730 44130 730 {lab=n6_ff.net2}
N 44690 730 44690 840 {lab=n6_ff.net2}
N 44690 840 44760 840 {lab=n6_ff.net2}
N 44760 840 44760 800 {lab=n6_ff.net2}
N 44760 840 44760 890 {lab=n6_ff.net2}
N 44130 730 44130 170 {lab=n6_ff.net2}
N 44130 170 44130 60 {lab=n6_ff.net2}
N 44130 170 44760 170 {lab=n6_ff.net2}
N 44130 60 44160 60 {lab=n6_ff.net2}
N 44760 170 44760 90 {lab=n6_ff.net2}
N 44760 170 44760 180 {lab=n6_ff.net2}
N 47480 770 47470 770 {lab=n7_ff.net2}
N 47470 770 47470 730 {lab=n7_ff.net2}
N 47470 730 48010 730 {lab=n7_ff.net2}
N 47470 730 47450 730 {lab=n7_ff.net2}
N 48010 730 48010 840 {lab=n7_ff.net2}
N 48010 840 48080 840 {lab=n7_ff.net2}
N 48080 840 48080 890 {lab=n7_ff.net2}
N 48080 840 48080 800 {lab=n7_ff.net2}
N 47450 730 47450 170 {lab=n7_ff.net2}
N 47450 170 47450 60 {lab=n7_ff.net2}
N 47450 170 48080 170 {lab=n7_ff.net2}
N 47450 60 47480 60 {lab=n7_ff.net2}
N 48080 170 48080 180 {lab=n7_ff.net2}
N 48080 170 48080 90 {lab=n7_ff.net2}
N 50800 770 50790 770 {lab=n8_ff.net2}
N 50790 770 50770 770 {lab=n8_ff.net2}
N 50790 770 50790 850 {lab=n8_ff.net2}
N 50790 850 51400 850 {lab=n8_ff.net2}
N 51400 850 51400 800 {lab=n8_ff.net2}
N 51400 850 51400 890 {lab=n8_ff.net2}
N 50770 770 50770 170 {lab=n8_ff.net2}
N 50770 170 51400 170 {lab=n8_ff.net2}
N 50770 170 50770 60 {lab=n8_ff.net2}
N 50770 60 50800 60 {lab=n8_ff.net2}
N 51400 170 51400 90 {lab=n8_ff.net2}
N 51400 170 51400 180 {lab=n8_ff.net2}
N 55440 770 55430 770 {lab=n9_ff.net2}
N 55430 770 55430 830 {lab=n9_ff.net2}
N 55430 770 55410 770 {lab=n9_ff.net2}
N 55430 830 56040 830 {lab=n9_ff.net2}
N 56040 830 56040 800 {lab=n9_ff.net2}
N 56040 830 56040 890 {lab=n9_ff.net2}
N 55410 770 55410 170 {lab=n9_ff.net2}
N 55410 170 56040 170 {lab=n9_ff.net2}
N 55410 170 55410 60 {lab=n9_ff.net2}
N 55410 60 55440 60 {lab=n9_ff.net2}
N 56040 170 56040 180 {lab=n9_ff.net2}
N 56040 170 56040 90 {lab=n9_ff.net2}
N 23360 890 23400 890 {lab=n_16}
N 23360 890 23360 90 {lab=n_16}
N 23400 890 23400 920 {lab=n_16}
N 23400 920 23680 920 {lab=n_16}
N 23360 90 23400 90 {lab=n_16}
N 23400 90 23400 60 {lab=n_16}
N 23400 60 23670 60 {lab=n_16}
N 23670 60 23680 60 {lab=n_16}
N 23670 60 23670 0 {lab=n_16}
N 23670 0 56620 0 {lab=n_16}
N 56620 0 56620 550 {lab=n_16}
N 53920 920 53890 920 {lab=n_n_10}
N 53890 920 53890 60 {lab=n_n_10}
N 53890 920 53890 1060 {lab=n_n_10}
N 53890 60 53920 60 {lab=n_n_10}
N 53890 1060 5180 1060 {lab=n_n_10}
N 5180 1060 5180 890 {lab=n_n_10}
N 5180 890 5120 890 {lab=n_n_10}
N 5120 890 5120 90 {lab=n_n_10}
N 55240 920 55210 920 {lab=n_n_9}
N 55210 920 55210 1040 {lab=n_n_9}
N 55210 920 55210 60 {lab=n_n_9}
N 55210 60 55240 60 {lab=n_n_9}
N 55210 1040 53640 1040 {lab=n_n_9}
N 53640 1040 53640 890 {lab=n_n_9}
N 53640 890 53600 890 {lab=n_n_9}
N 53600 890 53600 90 {lab=n_n_9}
N 8160 920 8130 920 {lab=n_n_11}
N 8130 920 8130 790 {lab=n_n_11}
N 8130 790 8130 60 {lab=n_n_11}
N 8130 790 7120 790 {lab=n_n_11}
N 8130 60 8160 60 {lab=n_n_11}
N 7120 790 7120 890 {lab=n_n_11}
N 7120 790 7120 90 {lab=n_n_11}
N 11480 920 11450 920 {lab=n_n_12}
N 11450 920 11450 820 {lab=n_n_12}
N 11450 820 11450 60 {lab=n_n_12}
N 11450 820 10440 820 {lab=n_n_12}
N 11450 60 11480 60 {lab=n_n_12}
N 10440 820 10440 890 {lab=n_n_12}
N 10440 820 10440 90 {lab=n_n_12}
N 14800 920 14770 920 {lab=n_n_13}
N 14770 920 14770 820 {lab=n_n_13}
N 14770 820 13760 820 {lab=n_n_13}
N 14770 820 14770 60 {lab=n_n_13}
N 14770 60 14800 60 {lab=n_n_13}
N 13760 820 13760 890 {lab=n_n_13}
N 13760 820 13760 90 {lab=n_n_13}
N 18120 920 18090 920 {lab=n_n_14}
N 18090 920 18090 820 {lab=n_n_14}
N 18090 820 17080 820 {lab=n_n_14}
N 18090 820 18090 60 {lab=n_n_14}
N 18090 60 18120 60 {lab=n_n_14}
N 17080 820 17080 90 {lab=n_n_14}
N 17080 820 17080 890 {lab=n_n_14}
N 21440 920 21410 920 {lab=n_n_15}
N 21410 920 21410 820 {lab=n_n_15}
N 21410 820 20400 820 {lab=n_n_15}
N 21410 820 21410 60 {lab=n_n_15}
N 21410 60 21440 60 {lab=n_n_15}
N 20400 820 20400 890 {lab=n_n_15}
N 20400 820 20400 90 {lab=n_n_15}
N 27360 920 27330 920 {lab=n_n_1}
N 27330 920 27330 810 {lab=n_n_1}
N 27330 810 26320 810 {lab=n_n_1}
N 27330 810 27330 60 {lab=n_n_1}
N 27330 60 27360 60 {lab=n_n_1}
N 26320 810 26320 890 {lab=n_n_1}
N 26320 810 26320 90 {lab=n_n_1}
N 30680 920 30650 920 {lab=n_n_2}
N 30650 920 30650 810 {lab=n_n_2}
N 30650 810 30650 60 {lab=n_n_2}
N 30650 810 29640 810 {lab=n_n_2}
N 30650 60 30680 60 {lab=n_n_2}
N 29640 810 29640 890 {lab=n_n_2}
N 29640 810 29640 90 {lab=n_n_2}
N 34000 920 33970 920 {lab=n_n_3}
N 33970 920 33970 810 {lab=n_n_3}
N 33970 810 32960 810 {lab=n_n_3}
N 33970 810 33970 60 {lab=n_n_3}
N 33970 60 34000 60 {lab=n_n_3}
N 32960 810 32960 890 {lab=n_n_3}
N 32960 810 32960 90 {lab=n_n_3}
N 37320 920 37290 920 {lab=n_n_4}
N 37290 920 37290 810 {lab=n_n_4}
N 37290 810 36280 810 {lab=n_n_4}
N 37290 810 37290 60 {lab=n_n_4}
N 37290 60 37320 60 {lab=n_n_4}
N 36280 810 36280 90 {lab=n_n_4}
N 36280 810 36280 890 {lab=n_n_4}
N 40640 920 40610 920 {lab=n_n_5}
N 40610 920 40610 810 {lab=n_n_5}
N 40610 810 40610 60 {lab=n_n_5}
N 40610 810 39600 810 {lab=n_n_5}
N 40610 60 40640 60 {lab=n_n_5}
N 39600 810 39600 890 {lab=n_n_5}
N 39600 810 39600 90 {lab=n_n_5}
N 43960 920 43930 920 {lab=n_n_6}
N 43930 920 43930 810 {lab=n_n_6}
N 43930 810 42920 810 {lab=n_n_6}
N 43930 810 43930 60 {lab=n_n_6}
N 43930 60 43960 60 {lab=n_n_6}
N 42920 810 42920 890 {lab=n_n_6}
N 42920 810 42920 90 {lab=n_n_6}
N 47280 920 47250 920 {lab=n_n_7}
N 47250 920 47250 810 {lab=n_n_7}
N 47250 810 47250 60 {lab=n_n_7}
N 47250 810 46240 810 {lab=n_n_7}
N 47250 60 47280 60 {lab=n_n_7}
N 46240 810 46240 90 {lab=n_n_7}
N 46240 810 46240 890 {lab=n_n_7}
N 50600 920 50570 920 {lab=n_n_8}
N 50570 920 50570 840 {lab=n_n_8}
N 50570 840 49560 840 {lab=n_n_8}
N 50570 840 50570 60 {lab=n_n_8}
N 50570 60 50600 60 {lab=n_n_8}
N 49560 840 49560 90 {lab=n_n_8}
N 49560 840 49560 890 {lab=n_n_8}
N 1440 890 1480 890 {lab=n_0}
N 1440 890 1440 90 {lab=n_0}
N 1480 890 1480 920 {lab=n_0}
N 1480 920 1760 920 {lab=n_0}
N 1440 90 1480 90 {lab=n_0}
N 1480 90 1480 60 {lab=n_0}
N 1480 60 1760 60 {lab=n_0}
N 24040 920 24010 920 {lab=n_n_16}
N 24010 920 23760 920 {lab=n_n_16}
N 24010 920 24010 90 {lab=n_n_16}
N 23760 920 23760 890 {lab=n_n_16}
N 23760 890 23720 890 {lab=n_n_16}
N 24010 90 23720 90 {lab=n_n_16}
N 24010 90 24010 60 {lab=n_n_16}
N 24010 60 24040 60 {lab=n_n_16}
N 2880 890 2880 830 {lab=n0_ff.net6}
N 2880 830 2920 830 {lab=n0_ff.net6}
N 2880 830 2880 800 {lab=n0_ff.net6}
N 2920 830 2920 180 {lab=n0_ff.net6}
N 2920 180 2880 180 {lab=n0_ff.net6}
N 2880 180 2880 90 {lab=n0_ff.net6}
N 3840 800 3840 890 {lab=n0_ff.net11}
N 3840 800 3880 800 {lab=n0_ff.net11}
N 3880 800 3880 180 {lab=n0_ff.net11}
N 3880 180 3840 180 {lab=n0_ff.net11}
N 3840 180 3840 90 {lab=n0_ff.net11}
N 53960 890 53960 800 {lab=n10_ff.net6}
N 53960 800 54000 800 {lab=n10_ff.net6}
N 54000 800 54000 180 {lab=n10_ff.net6}
N 54000 180 53960 180 {lab=n10_ff.net6}
N 53960 180 53960 90 {lab=n10_ff.net6}
N 54920 800 54920 830 {lab=n10_ff.net11}
N 54920 830 54980 830 {lab=n10_ff.net11}
N 54920 830 54920 890 {lab=n10_ff.net11}
N 54980 830 54980 180 {lab=n10_ff.net11}
N 54980 180 54920 180 {lab=n10_ff.net11}
N 54920 180 54920 90 {lab=n10_ff.net11}
N 8200 890 8200 800 {lab=n11_ff.net6}
N 8200 800 8240 800 {lab=n11_ff.net6}
N 8240 800 8240 180 {lab=n11_ff.net6}
N 8240 180 8200 180 {lab=n11_ff.net6}
N 8200 180 8200 90 {lab=n11_ff.net6}
N 9160 800 9160 830 {lab=n11_ff.net11}
N 9160 830 9160 890 {lab=n11_ff.net11}
N 9160 830 9200 830 {lab=n11_ff.net11}
N 9200 830 9200 180 {lab=n11_ff.net11}
N 9200 180 9160 180 {lab=n11_ff.net11}
N 9160 180 9160 90 {lab=n11_ff.net11}
N 11520 890 11520 800 {lab=n12_ff.net6}
N 11520 800 11560 800 {lab=n12_ff.net6}
N 11560 800 11560 180 {lab=n12_ff.net6}
N 11560 180 11520 180 {lab=n12_ff.net6}
N 11520 180 11520 90 {lab=n12_ff.net6}
N 12480 800 12520 800 {lab=n12_ff.net11}
N 12480 800 12480 890 {lab=n12_ff.net11}
N 12520 800 12520 180 {lab=n12_ff.net11}
N 12520 180 12480 180 {lab=n12_ff.net11}
N 12480 180 12480 90 {lab=n12_ff.net11}
N 14840 890 14840 800 {lab=n13_ff.net6}
N 14840 800 14880 800 {lab=n13_ff.net6}
N 14880 800 14880 180 {lab=n13_ff.net6}
N 14880 180 14840 180 {lab=n13_ff.net6}
N 14840 180 14840 90 {lab=n13_ff.net6}
N 15800 800 15800 890 {lab=n13_ff.net11}
N 15800 800 15840 800 {lab=n13_ff.net11}
N 15840 800 15840 180 {lab=n13_ff.net11}
N 15840 180 15800 180 {lab=n13_ff.net11}
N 15800 180 15800 90 {lab=n13_ff.net11}
N 18160 890 18160 800 {lab=n14_ff.net6}
N 18160 800 18200 800 {lab=n14_ff.net6}
N 18200 800 18200 180 {lab=n14_ff.net6}
N 18200 180 18160 180 {lab=n14_ff.net6}
N 18160 180 18160 90 {lab=n14_ff.net6}
N 19120 800 19120 890 {lab=n14_ff.net11}
N 19120 800 19160 800 {lab=n14_ff.net11}
N 19160 800 19160 180 {lab=n14_ff.net11}
N 19160 180 19120 180 {lab=n14_ff.net11}
N 19120 180 19120 90 {lab=n14_ff.net11}
N 21480 890 21480 800 {lab=n15_ff.net6}
N 21480 800 21520 800 {lab=n15_ff.net6}
N 21520 800 21520 180 {lab=n15_ff.net6}
N 21520 180 21480 180 {lab=n15_ff.net6}
N 21480 180 21480 90 {lab=n15_ff.net6}
N 22440 800 22480 800 {lab=n15_ff.net11}
N 22440 800 22440 890 {lab=n15_ff.net11}
N 22480 800 22480 180 {lab=n15_ff.net11}
N 22480 180 22440 180 {lab=n15_ff.net11}
N 22440 180 22440 90 {lab=n15_ff.net11}
N 24080 890 24080 830 {lab=n16_ff.net6}
N 24080 830 24080 800 {lab=n16_ff.net6}
N 24080 830 24120 830 {lab=n16_ff.net6}
N 24120 830 24120 180 {lab=n16_ff.net6}
N 24120 180 24080 180 {lab=n16_ff.net6}
N 24080 180 24080 90 {lab=n16_ff.net6}
N 25040 800 25040 890 {lab=n16_ff.net11}
N 25040 800 25080 800 {lab=n16_ff.net11}
N 25080 800 25080 180 {lab=n16_ff.net11}
N 25080 180 25040 180 {lab=n16_ff.net11}
N 25040 180 25040 90 {lab=n16_ff.net11}
N 27400 890 27400 800 {lab=n1_ff.net6}
N 27400 800 27440 800 {lab=n1_ff.net6}
N 27440 800 27440 180 {lab=n1_ff.net6}
N 27440 180 27400 180 {lab=n1_ff.net6}
N 27400 180 27400 90 {lab=n1_ff.net6}
N 28360 800 28400 800 {lab=n1_ff.net11}
N 28360 800 28360 890 {lab=n1_ff.net11}
N 28400 800 28400 180 {lab=n1_ff.net11}
N 28400 180 28360 180 {lab=n1_ff.net11}
N 28360 180 28360 90 {lab=n1_ff.net11}
N 30720 890 30720 800 {lab=n2_ff.net6}
N 30720 800 30760 800 {lab=n2_ff.net6}
N 30760 800 30760 180 {lab=n2_ff.net6}
N 30760 180 30720 180 {lab=n2_ff.net6}
N 30720 180 30720 90 {lab=n2_ff.net6}
N 31680 800 31680 890 {lab=n2_ff.net11}
N 31680 800 31720 800 {lab=n2_ff.net11}
N 31720 800 31720 180 {lab=n2_ff.net11}
N 31720 180 31680 180 {lab=n2_ff.net11}
N 31680 180 31680 90 {lab=n2_ff.net11}
N 34040 890 34040 800 {lab=n3_ff.net6}
N 34040 800 34080 800 {lab=n3_ff.net6}
N 34080 800 34080 180 {lab=n3_ff.net6}
N 34080 180 34040 180 {lab=n3_ff.net6}
N 34040 180 34040 90 {lab=n3_ff.net6}
N 35000 800 35000 890 {lab=n3_ff.net11}
N 35000 800 35040 800 {lab=n3_ff.net11}
N 35040 800 35040 180 {lab=n3_ff.net11}
N 35040 180 35000 180 {lab=n3_ff.net11}
N 35000 180 35000 90 {lab=n3_ff.net11}
N 37360 890 37360 800 {lab=n4_ff.net6}
N 37360 800 37400 800 {lab=n4_ff.net6}
N 37400 800 37400 180 {lab=n4_ff.net6}
N 37400 180 37360 180 {lab=n4_ff.net6}
N 37360 180 37360 90 {lab=n4_ff.net6}
N 38320 800 38320 890 {lab=n4_ff.net11}
N 38320 800 38360 800 {lab=n4_ff.net11}
N 38360 800 38360 180 {lab=n4_ff.net11}
N 38360 180 38320 180 {lab=n4_ff.net11}
N 38320 180 38320 90 {lab=n4_ff.net11}
N 40680 890 40680 800 {lab=n5_ff.net6}
N 40680 800 40720 800 {lab=n5_ff.net6}
N 40720 800 40720 180 {lab=n5_ff.net6}
N 40720 180 40680 180 {lab=n5_ff.net6}
N 40680 180 40680 90 {lab=n5_ff.net6}
N 41640 800 41640 890 {lab=n5_ff.net11}
N 41640 800 41680 800 {lab=n5_ff.net11}
N 41680 800 41680 180 {lab=n5_ff.net11}
N 41680 180 41640 180 {lab=n5_ff.net11}
N 41640 180 41640 90 {lab=n5_ff.net11}
N 44000 890 44000 800 {lab=n6_ff.net6}
N 44000 800 44040 800 {lab=n6_ff.net6}
N 44040 800 44040 180 {lab=n6_ff.net6}
N 44040 180 44000 180 {lab=n6_ff.net6}
N 44000 180 44000 90 {lab=n6_ff.net6}
N 44960 800 44960 890 {lab=n6_ff.net11}
N 44960 800 45000 800 {lab=n6_ff.net11}
N 45000 800 45000 180 {lab=n6_ff.net11}
N 45000 180 44960 180 {lab=n6_ff.net11}
N 44960 180 44960 90 {lab=n6_ff.net11}
N 47320 890 47320 800 {lab=n7_ff.net6}
N 47320 800 47360 800 {lab=n7_ff.net6}
N 47360 800 47360 180 {lab=n7_ff.net6}
N 47360 180 47320 180 {lab=n7_ff.net6}
N 47320 180 47320 90 {lab=n7_ff.net6}
N 48280 800 48280 890 {lab=n7_ff.net11}
N 48280 800 48320 800 {lab=n7_ff.net11}
N 48320 800 48320 180 {lab=n7_ff.net11}
N 48320 180 48280 180 {lab=n7_ff.net11}
N 48280 180 48280 90 {lab=n7_ff.net11}
N 50640 890 50640 800 {lab=n8_ff.net6}
N 50640 800 50680 800 {lab=n8_ff.net6}
N 50680 800 50680 180 {lab=n8_ff.net6}
N 50680 180 50640 180 {lab=n8_ff.net6}
N 50640 180 50640 90 {lab=n8_ff.net6}
N 51600 800 51600 830 {lab=n8_ff.net11}
N 51600 830 51600 890 {lab=n8_ff.net11}
N 51600 830 51640 830 {lab=n8_ff.net11}
N 51640 830 51640 180 {lab=n8_ff.net11}
N 51640 180 51600 180 {lab=n8_ff.net11}
N 51600 180 51600 90 {lab=n8_ff.net11}
N 55280 890 55280 830 {lab=n9_ff.net6}
N 55280 830 55320 830 {lab=n9_ff.net6}
N 55280 830 55280 800 {lab=n9_ff.net6}
N 55320 830 55320 180 {lab=n9_ff.net6}
N 55320 180 55280 180 {lab=n9_ff.net6}
N 55280 180 55280 90 {lab=n9_ff.net6}
N 56240 800 56280 800 {lab=n9_ff.net11}
N 56240 800 56240 890 {lab=n9_ff.net11}
N 56280 800 56280 180 {lab=n9_ff.net11}
N 56280 180 56240 180 {lab=n9_ff.net11}
N 56240 180 56240 90 {lab=n9_ff.net11}
N 3280 180 3280 100 {lab=n0_ff.net9}
N 3280 100 3280 90 {lab=n0_ff.net9}
N 3280 100 3080 100 {lab=n0_ff.net9}
N 3080 100 3080 90 {lab=n0_ff.net9}
N 54360 180 54360 100 {lab=n10_ff.net9}
N 54360 100 54160 100 {lab=n10_ff.net9}
N 54360 100 54360 90 {lab=n10_ff.net9}
N 54160 100 54160 90 {lab=n10_ff.net9}
N 8600 180 8600 100 {lab=n11_ff.net9}
N 8600 100 8400 100 {lab=n11_ff.net9}
N 8600 100 8600 90 {lab=n11_ff.net9}
N 8400 100 8400 90 {lab=n11_ff.net9}
N 11920 180 11920 100 {lab=n12_ff.net9}
N 11920 100 11720 100 {lab=n12_ff.net9}
N 11920 100 11920 90 {lab=n12_ff.net9}
N 11720 100 11720 90 {lab=n12_ff.net9}
N 15240 180 15240 100 {lab=n13_ff.net9}
N 15240 100 15040 100 {lab=n13_ff.net9}
N 15240 100 15240 90 {lab=n13_ff.net9}
N 15040 100 15040 90 {lab=n13_ff.net9}
N 18560 180 18560 100 {lab=n14_ff.net9}
N 18560 100 18560 90 {lab=n14_ff.net9}
N 18560 100 18360 100 {lab=n14_ff.net9}
N 18360 100 18360 90 {lab=n14_ff.net9}
N 21880 180 21880 100 {lab=n15_ff.net9}
N 21880 100 21680 100 {lab=n15_ff.net9}
N 21880 100 21880 90 {lab=n15_ff.net9}
N 21680 100 21680 90 {lab=n15_ff.net9}
N 24480 180 24480 100 {lab=n16_ff.net9}
N 24480 100 24280 100 {lab=n16_ff.net9}
N 24480 100 24480 90 {lab=n16_ff.net9}
N 24280 100 24280 90 {lab=n16_ff.net9}
N 27800 180 27800 100 {lab=n1_ff.net9}
N 27800 100 27600 100 {lab=n1_ff.net9}
N 27800 100 27800 90 {lab=n1_ff.net9}
N 27600 100 27600 90 {lab=n1_ff.net9}
N 31120 180 31120 100 {lab=n2_ff.net9}
N 31120 100 30920 100 {lab=n2_ff.net9}
N 31120 100 31120 90 {lab=n2_ff.net9}
N 30920 100 30920 90 {lab=n2_ff.net9}
N 34440 180 34440 100 {lab=n3_ff.net9}
N 34440 100 34240 100 {lab=n3_ff.net9}
N 34440 100 34440 90 {lab=n3_ff.net9}
N 34240 100 34240 90 {lab=n3_ff.net9}
N 37760 180 37760 100 {lab=n4_ff.net9}
N 37760 100 37560 100 {lab=n4_ff.net9}
N 37760 100 37760 90 {lab=n4_ff.net9}
N 37560 100 37560 90 {lab=n4_ff.net9}
N 41080 180 41080 100 {lab=n5_ff.net9}
N 41080 100 40880 100 {lab=n5_ff.net9}
N 41080 100 41080 90 {lab=n5_ff.net9}
N 40880 100 40880 90 {lab=n5_ff.net9}
N 44400 180 44400 100 {lab=n6_ff.net9}
N 44400 100 44400 90 {lab=n6_ff.net9}
N 44400 100 44200 100 {lab=n6_ff.net9}
N 44200 100 44200 90 {lab=n6_ff.net9}
N 47720 180 47720 100 {lab=n7_ff.net9}
N 47720 100 47720 90 {lab=n7_ff.net9}
N 47720 100 47520 100 {lab=n7_ff.net9}
N 47520 100 47520 90 {lab=n7_ff.net9}
N 51040 180 51040 100 {lab=n8_ff.net9}
N 51040 100 50840 100 {lab=n8_ff.net9}
N 51040 100 51040 90 {lab=n8_ff.net9}
N 50840 100 50840 90 {lab=n8_ff.net9}
N 55680 180 55680 100 {lab=n9_ff.net9}
N 55680 100 55480 100 {lab=n9_ff.net9}
N 55680 100 55680 90 {lab=n9_ff.net9}
N 55480 100 55480 90 {lab=n9_ff.net9}
N 120 920 -60 920 {lab=tick_n}
N -60 920 -60 570 {lab=tick_n}
N -60 570 -70 570 {lab=tick_n}
N -70 570 -70 60 {lab=tick_n}
N -70 60 120 60 {lab=tick_n}
N 3080 650 3080 740 {lab=n0_ff.net15}
N 3080 800 3080 890 {lab=n0_ff.net12}
N 880 890 880 800 {lab=n0_ff.net0}
N 54160 650 54160 740 {lab=n10_ff.net15}
N 54160 800 54160 890 {lab=n10_ff.net12}
N 4200 890 4200 800 {lab=n10_ff.net0}
N 8400 650 8400 740 {lab=n11_ff.net15}
N 8400 800 8400 890 {lab=n11_ff.net12}
N 6200 890 6200 800 {lab=n11_ff.net0}
N 11720 650 11720 740 {lab=n12_ff.net15}
N 11720 800 11720 890 {lab=n12_ff.net12}
N 9520 890 9520 800 {lab=n12_ff.net0}
N 15040 650 15040 740 {lab=n13_ff.net15}
N 15040 800 15040 890 {lab=n13_ff.net12}
N 12840 890 12840 800 {lab=n13_ff.net0}
N 18360 650 18360 740 {lab=n14_ff.net15}
N 18360 800 18360 890 {lab=n14_ff.net12}
N 16160 890 16160 800 {lab=n14_ff.net0}
N 21680 650 21680 740 {lab=n15_ff.net15}
N 21680 800 21680 890 {lab=n15_ff.net12}
N 19480 890 19480 800 {lab=n15_ff.net0}
N 24280 650 24280 740 {lab=n16_ff.net15}
N 24280 800 24280 890 {lab=n16_ff.net12}
N 22800 890 22800 800 {lab=n16_ff.net0}
N 27600 650 27600 740 {lab=n1_ff.net15}
N 27600 800 27600 890 {lab=n1_ff.net12}
N 25400 890 25400 800 {lab=n1_ff.net0}
N 30920 650 30920 740 {lab=n2_ff.net15}
N 30920 800 30920 890 {lab=n2_ff.net12}
N 28720 890 28720 800 {lab=n2_ff.net0}
N 34240 650 34240 740 {lab=n3_ff.net15}
N 34240 800 34240 890 {lab=n3_ff.net12}
N 32040 890 32040 800 {lab=n3_ff.net0}
N 37560 650 37560 740 {lab=n4_ff.net15}
N 37560 800 37560 890 {lab=n4_ff.net12}
N 35360 890 35360 800 {lab=n4_ff.net0}
N 40880 650 40880 740 {lab=n5_ff.net15}
N 40880 800 40880 890 {lab=n5_ff.net12}
N 38680 890 38680 800 {lab=n5_ff.net0}
N 44200 650 44200 740 {lab=n6_ff.net15}
N 44200 800 44200 890 {lab=n6_ff.net12}
N 42000 890 42000 800 {lab=n6_ff.net0}
N 47520 650 47520 740 {lab=n7_ff.net15}
N 47520 800 47520 890 {lab=n7_ff.net12}
N 45320 890 45320 800 {lab=n7_ff.net0}
N 50840 650 50840 740 {lab=n8_ff.net15}
N 50840 800 50840 890 {lab=n8_ff.net12}
N 48640 890 48640 800 {lab=n8_ff.net0}
N 55480 650 55480 740 {lab=n9_ff.net15}
N 55480 800 55480 890 {lab=n9_ff.net12}
N 51960 890 51960 800 {lab=n9_ff.net0}
C {devices/ipin.sym} -60 530 0 0 {name=p851 lab=run}
C {devices/ipin.sym} -60 570 0 0 {name=p852 lab=tick_n}
C {devices/opin.sym} 56620 550 0 0 {name=p853 lab=n_16}
